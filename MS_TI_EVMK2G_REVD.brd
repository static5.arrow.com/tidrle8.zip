# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_MCASP2AXR1: length 29.3
  TOP w0.127: R423.1 198.17,134.38 199.59,135.8 202.13,135.8 202.82,136.49 209.3,136.49 210.46,137.66 210.46,150.36 209.62,151.21 U135.3
SOC_MCASP2AXR2: length 38.4
  L08_SIG2 w0.127: v2(198.63,129.1) 199.87,129.1 200.71,129.94 200.71,132.63 199.77,133.57 198.78,133.57 196.65,135.7 196.65,137.51 194.44,139.71 193.29,139.71 192.79,140.22 192.79,143.09 195.44,145.75 195.44,148.48 200.3,153.35 v2(200.3,154.65)
  BOTTOM w0.127: v2(200.3,154.65) 199.82,154.17 U136.6 ; R433.1 198.36,128.28 198.63,128.55 v2(198.63,129.1)
SOC_MCASP2AXR3: length 27.5
  TOP w0.127: R415.1 198.24,136.39 202.31,136.39 202.72,136.79 208.81,136.79 209.4,137.38 209.4,137.94 208.81,138.52 207.47,138.52 206.83,139.16 206.83,148.1 v2(207.37,148.63)
  BOTTOM w0.127: v2(207.37,148.63) 206.69,149.31 U137.4
SOC_MCASP2AXR4: length 38.8
  TOP w0.127: v2(199.77,132.86) 199.31,133.31 198.82,133.31 198.36,132.86 R396.1 ; U64.11 v2(199.83,155.22)
  L08_SIG2 w0.127: v2(199.77,132.86) 199.28,132.36 198.8,132.36 198.56,132.6 198.37,132.6 198.25,132.73 193.48,132.73 193.31,132.91 193.31,132.92 191.67,134.56 191.67,143.68 193.4,145.4 193.4,148.58 198.3,153.48 198.3,154.75 198.77,155.22 v2(199.83,155.22)
SOC_MCASP2AXR5: length 113.2
  L03_SIG1 w0.127: JP1.24 301.31,114.54 298.99,114.54 293.86,119.67 261.44,119.67 251.1,130.01 250.95,130.01 250.93,130.04 223.92,130.04 221.78,132.17 204.28,132.17 203.52,132.93 200.38,132.93 199.9,133.42 199.57,133.42 v2(199.01,132.86)
  BOTTOM w0.127: R420.1 v2(199.01,132.86)
SOC_MCASP2FSR: length 116.6
  L03_SIG1 w0.127: JP1.18 301.36,122.21 261.16,122.21 252.06,131.32 224.78,131.32 220.83,135.27 207.14,135.27 205.94,136.46 196.04,136.46 v2(195.1,135.52)
  BOTTOM w0.127: R409.1 194.36,135.7 194.54,135.52 v2(195.1,135.52)
SOC_MCASP2FSX: length 26.8
  TOP w0.127: U64.12 v2(199.18,153.86)
  L08_SIG2 w0.127: v2(193.93,134.63) 193.32,135.24 193.32,136.51 191.95,137.89 191.95,143.32 192.02,143.4 192.02,143.41 194.68,146.07 194.68,148.8 199.18,153.3 v2(199.18,153.86)
  BOTTOM w0.127: U136.5 199.18,152.61 v2(199.18,153.86) ; v2(193.93,134.63) 193.67,134.38 R411.1
SOC_MCBSPCLKR: length 200.9
  TOP w0.127: v2(298.77,171.66) 298.6,171.82 298.6,200.06 J12.29 ; U1.D17 v1(181.21,116.21)
  L08_SIG2 w0.102: v1(181.21,116.21) 181.6,115.83 182.74,115.83 183.26,115.31 189,115.31 189.1,115.2
  L08_SIG2 w0.127: v2(223.39,114.47) 222.58,113.65 217.37,113.65 212.39,118.63 204.1,118.63 201.87,116.4 201.72,116.4 201.72,116.4 201.02,116.4 200.94,116.47 198.98,116.47 198.9,116.4 197.83,116.4 196.56,115.13 196.56,115.13 196.46,115.03 190.91,115.03 190.87,115.06 189.24,115.06 189.1,115.2
  BOTTOM w0.127: v2(298.77,171.66) 298.76,171.66 290.7,163.6 290.7,146.71 270.55,126.56 244.14,126.56 237.75,132.95 226.3,132.95 225.41,132.05 225.41,116.48 v2(223.39,114.47)
SOC_MCBSPCLKX: length 204.2
  TOP w0.127: v2(214.76,111.52) 213.96,110.72 204.94,110.72 202.9,112.77 198.91,112.77 198.63,112.49 198.63,112.18 198.62,112.18 198.47,112.03 195.81,112.03 195.68,112.16 195.68,112.83 195.51,113.01 195.51,113.04 194.38,114.16 190.88,114.16 188.87,116.17 185.47,116.17 184.68,116.96 183.42,116.96 183.37,117.01 182.8,117.01 182.75,116.96 182.75,116.96 U1.B16
  BOTTOM w0.127: v2(214.76,111.52) 214.96,111.32 215.79,111.32 217.25,112.77 217.25,118.18 219.1,120.03 219.1,135.01 221.43,137.34 241.17,137.34 247.31,131.19 268.68,131.19 285.66,148.17 285.66,178.01 297.05,189.4 297.05,203.59 J12.25
SOC_MCBSPDR: length 207.8
  TOP w0.127: U1.D15 v1(181.21,117.81) ; J12.19 298.46,214.11 297.18,212.83 297.18,177.59 295.34,175.74 v2(295.34,175.34)
  L08_SIG2 w0.102: v1(181.21,117.81) 181.6,117.43 183.2,117.43 183.39,117.24 189.1,117.24
  L08_SIG2 w0.127: 189.1,117.24 189.97,117.24 191.17,116.03 196.19,116.03 197.55,117.39 201.32,117.39 203.43,119.5 222.49,119.5 222.9,119.9 v2(223.65,119.9)
  BOTTOM w0.127: v2(223.65,119.9) 223.65,132.98 224.51,133.85 238.4,133.85 244.79,127.46 270.23,127.46 289.43,146.66 289.43,169.43 v2(295.34,175.34)
SOC_MCBSPDX: length 207.7
  TOP w0.127: U1.A16 183.3,116.7 184.56,116.7 185.37,115.89 188.65,115.89 190.73,113.81 194.23,113.81 195.15,112.89 195.15,112.86 195.33,112.68 195.33,112.01 195.66,111.67 198.62,111.67 198.77,111.82 198.98,111.82 198.99,111.83 199.34,111.83 199.55,112.04 202.8,112.04 204.47,110.37 214.43,110.37 215.52,111.45 v2(215.52,111.77)
  BOTTOM w0.127: J12.21 298.77,210.38 298.77,206.45 296.67,204.36 296.67,189.56 285.28,178.17 285.28,148.33 268.53,131.57 247.47,131.57 241.32,137.72 221.12,137.72 218.72,135.32 218.72,120.36 216.71,118.36 216.71,112.97 v2(215.52,111.77)
SOC_MCBSPFSR: length 204.7
  TOP w0.127: J12.27 298.55,203.95 298.15,203.55 298.15,173.57 v2(297.75,173.18) ; U1.C16 v1(182.01,117.01)
  L08_SIG2 w0.102: v1(182.01,117.01) 182.95,117.01 183.26,116.7 184.71,116.7 185.22,116.19 187.37,116.19 187.72,116.55 189.1,116.55
  L08_SIG2 w0.127: 189.1,116.55 190.27,116.55 191.07,115.75 196.31,115.75 197.67,117.11 201.55,117.11 203.7,119.26 221.35,119.26 222.25,118.35 v2(222.25,114.49)
  BOTTOM w0.127: v2(297.75,173.18) 290.27,165.7 290.27,146.82 270.39,126.94 244.29,126.94 237.91,133.33 226.15,133.33 225.02,132.2 225.02,117.26 v2(222.25,114.49)
SOC_MCBSPFSX: length 211.3
  TOP w0.127: v2(296.99,175.8) 297.84,176.65 297.84,208.57 298.29,209.03 J12.23 ; U1.E15 v1(180.41,117.01)
  L03_SIG1 w0.102: 188.82,114.85 188.67,115 186.28,115 184.68,116.6 180.82,116.6 v1(180.41,117.01)
  L03_SIG1 w0.127: v2(220.98,114.31) 220.54,114.31 219.77,115.08 208.84,115.08 207.7,113.93 207.7,110.96 206.98,110.25 202.08,110.25 199.31,113.02 195.51,113.02 194.4,114.13 189.55,114.13 188.82,114.85
  BOTTOM w0.127: v2(296.99,175.8) 289.92,168.72 289.92,146.8 270.29,127.18 244.56,127.18 238.17,133.57 226.05,133.57 224.66,132.19 224.66,118 v2(220.98,114.31)
SOC_MDIO_CLK: length 163.7
  TOP w0.127: v2(168.2,56.66) 168.58,56.28 169.13,56.28 169.97,55.44 U92.36 ; U1.U3 v1(170.01,126.61)
  BOTTOM w0.102: 177.89,134.51 176.95,133.57 174.93,133.57 174.52,133.16 173.48,133.16 172.92,132.6 172.92,132.22 171.68,130.98 171.68,127.47 171.22,127.01 170.41,127.01 v1(170.01,126.61) ; 165.06,69.69 165.06,69.66 165.07,69.65 165.07,61.61 163.07,59.6 163.07,59.25
  BOTTOM w0.127: 177.89,134.51 178.09,134.71 183.85,134.71 185.98,136.84 188.59,136.84 188.85,137.11 189.29,137.54 189.3,137.54 190.33,138.57 191.85,138.57 192.86,139.59 194.57,139.59 195.05,140.07 202.13,140.07 206.2,136 206.2,129.73 205.46,129 205.46,114.49 204.67,113.71 204.67,106.02 200.55,101.9 200.33,101.67 200.33,94.08 199.21,92.95 198.98,92.73 198.98,86.48 194.81,82.31 188.06,82.31 178.79,73.04 166.79,73.04 165.06,71.31 165.06,69.69 ; v2(168.2,56.66) 167.88,56.97 165.25,56.97 164.85,56.57 164.58,56.57 164.39,56.38 164.39,56.32 163.97,55.89 R767.2 163.22,55.89 163.07,56.05 163.07,59.25
SOC_MDIO_DATA: length 159.7
  TOP w0.127: U1.V3 v1(170.01,127.41) ; v2(168.45,55.39) 168.45,54.8 168.88,54.38 U92.37
  BOTTOM w0.102: v1(170.01,127.41) 171.37,128.78 171.37,131.94 173.51,134.08 174.78,134.08 175.03,133.82 176.81,133.82 177.88,134.89 ; 165.73,59.25 165.07,59.91 165.07,60.95 165.54,61.42 165.54,69.65 165.55,69.66 165.55,69.69
  BOTTOM w0.127: 165.55,69.69 165.55,71.11 166.99,72.55 178.83,72.55 188.21,81.93 194.97,81.93 199.36,86.32 199.36,92.57 200.71,93.92 200.71,101.51 205.05,105.86 205.05,113.45 205.89,114.29 205.89,128.87 206.58,129.55 206.58,136.16 202.29,140.45 194.89,140.45 194.44,139.99 192.63,139.99 191.59,138.95 190.16,138.95 188.43,137.23 185.82,137.23 183.59,134.99 177.98,134.99 177.88,134.89 ; 165.73,59.25 165.93,59.05 R770.2 167.82,58.18 168.68,57.32 168.68,56.38 168.45,56.15 v2(168.45,55.39)
SOC_MLB_GPIO2: length 177.8
  TOP w0.127: J34.24 130.27,11.66 130.3,11.63 v2(130.3,11.14) ; U1.C14 v1(182.01,118.61)
  L03_SIG1 w0.127: v2(165.35,33.16) 164.69,33.82 132.69,33.82 129.06,30.19 129.06,28.39 130.53,26.91 130.53,22.67 128.47,20.61 128.47,11.65 128.98,11.14 v2(130.3,11.14)
  L08_SIG2 w0.127: v2(165.35,33.16) 167.59,35.4 167.59,38.37 170.46,41.24 170.46,48.48 171.75,49.77 171.75,54.42 171.65,54.52 171.65,57.52 169.27,59.91 169.27,66.14 169.39,66.26 170.33,67.2 170.33,67.2 170.43,67.3 181.81,67.3 188.21,73.7 188.21,81.93 187.45,82.69 v2(187.45,84.77)
  BOTTOM w0.127: v2(187.45,84.77) 189.25,84.77 189.87,85.39 189.87,88.74 190.27,89.14 191.16,89.14 191.59,89.58 191.59,93.82 190.98,94.43 190.98,99.5 189.65,100.83 187.22,100.83 184.84,103.21 184.84,107.64 185.17,107.96 185.17,110.4 183.69,111.88 183.69,113.78 182.45,115.02 180.92,115.02 180.8,115.14 180.8,118.08 180.93,118.21 181.6,118.21 v1(182.01,118.61)
SOC_MLB_PCLKN: length 148.4
  TOP w0.102: J34.17 132.27,20.04 132.19,20.13 132.19,21.01 v2(132.53,21.36) 132.26,21.62 132.26,22.3 132.61,22.64 133.14,22.64 133.94,23.44 133.94,24.96 134.02,25.04 R572.2
  TOP w0.127: U1.L23 v1(174.81,110.61)
  L03_SIG1 w0.102: v2(132.53,21.36) 132.18,21.71 132.18,23.05 135.42,26.3 135.42,28.53 J27.2
  L08_SIG2 w0.102: v1(174.81,110.61) 174.68,110.48 174.68,110.23 174.86,110.04 174.98,110.04 175.11,109.92 175.11,109.78 175,109.67 175,109.56 175.49,109.06 176.48,109.06 177.22,108.33 177.22,107.8 177.55,107.47 177.55,106.68 179.49,104.74 179.93,104.74 181.27,103.4 181.27,98.48 184.96,94.78 184.96,92.98 185.56,92.38 185.56,79.74 187.05,78.25 187.05,75.38 180.04,68.37 169.8,68.37 167.41,65.97 167.41,65.68 167.41,59.86 167.62,59.65 169.4,57.88 169.4,49.14 155.07,34.81 137.92,34.81 135.49,32.37 135.49,30.82 J27.2
  BOTTOM w0.102: v2(132.53,21.36) 132.18,21.01 132.18,19.41 R773.1
SOC_MLB_PCLKP: length 148.4
  TOP w0.102: R571.2 133.5,25.04 133.61,24.93 133.61,23.58 133,22.97 132.47,22.97 131.93,22.44 131.93,21.78 v2(131.51,21.36) 131.86,21.01 131.86,20.13 131.77,20.04 J34.19
  TOP w0.127: U1.M23 v1(174.01,110.61)
  L03_SIG1 w0.102: J27.1 135.15,28.62 135.15,26.41 131.91,23.16 131.91,21.75 v2(131.51,21.36)
  L08_SIG2 w0.102: J27.1 135.22,30.87 135.22,32.48 137.81,35.07 154.96,35.07 169.13,49.25 169.13,57.77 167.51,59.39 167.14,59.75 167.14,65.57 167.14,66.08 169.69,68.63 179.92,68.63 186.78,75.49 186.78,78.13 185.29,79.63 185.29,92.27 184.7,92.86 184.7,94.67 181,98.37 181,103.29 179.82,104.47 179.38,104.47 177.28,106.57 177.28,107.36 176.95,107.69 176.95,108.22 176.37,108.8 175.38,108.8 174.68,109.49 174.68,109.84 174.4,110.12 174.4,110.22 174.01,110.61 v1(174.01,110.61)
  BOTTOM w0.102: v2(131.51,21.36) 131.85,21.01 131.85,19.39 R773.2
SOC_MLB_PDATDN: length 148.4
  TOP w0.102: J34.9 135.27,20.04 135.19,20.13 135.19,21.03 v2(135.53,21.38) 135.25,21.65 135.25,22.26 136.99,23.99 136.99,24.94 137.09,25.04 R574.2
  TOP w0.127: U1.K22 v1(175.61,111.41)
  L03_SIG1 w0.102: J28.2 140.85,28.5 140.85,27.71 135.18,22.04 135.18,21.73 v2(135.53,21.38)
  L08_SIG2 w0.102: v1(175.61,111.41) 176.02,111 176.02,110.38 176.37,110.03 176.67,110.03 177.79,108.91 178.25,108.91 179.45,107.71 180.09,107.71 180.75,107.05 180.75,105.51 182.23,104.03 182.23,98.97 182.38,98.81 182.38,98.81 186.55,94.64 186.55,79.91 187.89,78.57 187.89,74.74 180.85,67.7 170.08,67.7 168.15,65.77 168.15,60.07 170.24,57.98 170.24,48.88 166.09,44.74 166.09,43.26 156.11,33.28 142.47,33.28 140.98,31.8 140.98,30.79 J28.2
  BOTTOM w0.102: v2(135.53,21.38) 135.2,21.04 135.2,20.94 135.23,20.91 135.23,17.48 135.35,17.36 135.63,17.36 135.73,17.26 R775.1
SOC_MLB_PDATDP: length 148.4
  TOP w0.102: J34.11 134.77,20.04 134.86,20.13 134.86,21.03 v2(134.51,21.38) 134.92,21.79 134.92,22.39 136.66,24.12 136.66,24.95 136.57,25.04 R573.2
  TOP w0.127: U1.K23 v1(175.61,110.61)
  L03_SIG1 w0.102: J28.1 140.58,28.65 140.58,27.82 134.87,22.11 134.87,21.73 v2(134.51,21.38)
  L08_SIG2 w0.102: J28.1 140.72,30.9 140.72,31.92 142.35,33.55 156,33.55 165.82,43.38 165.82,44.85 169.97,48.99 169.97,57.87 167.88,59.96 167.88,65.88 169.97,67.97 180.74,67.97 187.62,74.85 187.62,78.46 186.28,79.8 186.28,94.53 182.12,98.7 182.12,98.7 181.97,98.86 181.97,103.92 180.48,105.4 180.48,106.94 179.98,107.44 179.34,107.44 179.02,107.76 178.88,107.76 178.68,107.56 178.43,107.56 178.34,107.65 178.34,107.79 178.59,108.04 178.59,108.19 178.14,108.64 177.68,108.64 176.56,109.77 176.25,109.77 175.61,110.41 v1(175.61,110.61)
  BOTTOM w0.102: R775.2 134.43,17.26 134.53,17.36 134.8,17.36 134.9,17.46 134.9,20.74 134.85,20.8 134.85,21.04 v2(134.51,21.38)
SOC_MLB_PSIGN: length 137.4
  TOP w0.102: R576.2 140.28,25.04 140.03,24.79 140.03,24 138.15,22.11 138.15,21.76 v2(138.53,21.38) 138.19,21.03 138.19,20.13 138.27,20.04 J34.1
  TOP w0.127: v1(174.81,108.14) 174.81,109.81 U1.M24
  L03_SIG1 w0.102: J29.2 146.19,28.5 146.19,27.58 145.26,26.65 141.72,26.65 138.13,23.06 138.13,21.78 v2(138.53,21.38)
  L08_SIG2 w0.102: v1(174.81,108.14) 175.96,106.99 175.96,104.98 176.15,104.79 176.53,104.79 176.78,104.54 176.78,104.5 176.79,104.49 176.79,104.39 177.47,103.71 177.47,102.41 177.47,102.21 178.31,101.36 178.31,98.99 183.04,94.27 183.04,92.7 182.12,91.78 182.12,89.17 182.3,88.99 182.3,72.96 179.2,69.86 169.32,69.86 166.76,67.3 166.76,59.53 167.36,58.92 167.37,58.92 167.69,58.6 167.69,56.61 166.3,55.21 166.3,47.14 159.66,40.5 158.87,40.5 158.64,40.27 v2(158.64,40.19)
  BOTTOM w0.102: v2(138.53,21.38) 138.29,21.14 138.29,19.5 138.78,19.02 R774.1 ; v2(158.64,40.19) 158.3,40.53 150.76,40.53 146.3,36.07 146.3,30.8 J29.2
SOC_MLB_PSIGP: length 137
  TOP w0.102: R575.2 139.52,25.04 139.7,24.86 139.7,24.13 137.82,22.25 137.82,21.69 v2(137.51,21.38) 137.86,21.03 137.86,20.13 137.77,20.04 J34.3
  TOP w0.127: v1(176.41,104.33) 175.61,105.13 175.61,109.81 U1.L24
  L03_SIG1 w0.102: v2(137.51,21.38) 137.87,21.73 137.87,23.17 141.61,26.92 145.15,26.92 145.92,27.69 145.92,28.64 J29.1
  L08_SIG2 w0.102: v1(176.41,104.33) 177.19,103.55 177.19,102.1 178.05,101.24 178.05,98.88 178.31,98.62 182.77,94.16 182.77,92.81 181.85,91.89 181.85,89.06 182.03,88.88 182.03,73.07 179.09,70.13 169.21,70.13 166.49,67.41 166.49,59.42 167.25,58.66 167.26,58.66 167.42,58.49 167.42,56.72 166.03,55.32 166.03,47.25 159.55,40.77 159.04,40.77 v2(158.64,41.17)
  BOTTOM w0.102: R774.2 137.48,19.29 137.58,19.39 137.85,19.39 137.96,19.5 137.96,20.93 v2(137.51,21.38) ; v2(158.64,41.17) 158.32,40.86 150.62,40.86 145.97,36.21 145.97,30.82 J29.1
SOC_MLBCLK: length 176.6
  TOP w0.127: U1.AA24 167.61,109.81 167.61,105.46 v1(166.81,104.66) ; J34.2 138.27,14.33 138.43,14.49 147.95,14.49 155.27,21.81 155.27,28.94 J48.3
  L03_SIG1 w0.127: v2(137.03,41.42) 137.57,41.42 137.9,41.75 137.92,41.75 137.92,51.81 142.67,56.56 142.67,69.94 143.92,71.19 153.69,71.19 153.69,71.19 154.01,71.19 162.03,79.21 162.03,83.8 160.32,85.5 160.32,87.74 160.38,87.79 v2(160.38,88.15)
  BOTTOM w0.127: v1(166.81,104.66) 165.7,104.66 164.42,103.38 164.42,101.5 164.25,101.33 164.25,98.27 164.25,98.27 164.25,98.11 163.72,97.58 162.82,97.58 162.39,98.01 161.32,98.01 160.83,97.52 160.83,97.2 160.83,88.61 v2(160.38,88.15) ; v2(137.03,41.42) 133.77,41.42 127.38,35.03 127.38,24.25 128.57,23.05 136.86,23.05 138.84,25.03 151.36,25.03 J48.3
SOC_MLBDAT: length 171.5
  TOP w0.127: J34.10 135.27,14.89 135.51,15.13 145.82,15.13 150.95,20.26 J48.1 ; U1.W24 169.21,109.81 169.21,105.13 v1(170.01,104.33)
  L03_SIG1 w0.127: v2(137.79,40.71) 138.13,41.04 138.15,41.04 138.28,41.16 138.28,41.37 138.3,41.37 138.3,51.65 143.05,56.4 143.05,69.71 144.14,70.8 153.53,70.8 153.85,70.8 154.18,70.8 162.41,79.03 162.41,83.95 160.7,85.66 160.7,87.58 160.76,87.63 160.76,87.87 v2(161.21,88.33)
  BOTTOM w0.127: v2(137.79,40.71) 137.48,40.39 133.63,40.39 128.59,35.35 128.59,25.01 129.88,23.71 134.14,23.71 137.62,27.19 148.44,27.19 J48.1 ; v2(161.21,88.33) 161.21,97.36 161.48,97.63 162.23,97.63 162.5,97.36 162.5,97.36 162.66,97.2 163.4,97.2 163.88,97.2 164.41,97.73 164.42,97.73 164.63,97.95 164.63,100.87 164.63,101.17 164.8,101.34 164.8,102.86 166.17,104.23 167.73,104.23 167.99,103.96 169.64,103.96 v1(170.01,104.33)
SOC_MLBSIG: length 172
  TOP w0.127: J48.2 153.49,21.3 147.04,14.85 137.26,14.85 136.77,14.36 J34.6 ; v1(166.81,106.87) 167.21,107.27 U1.AA25
  L03_SIG1 w0.127: v2(161.16,87.39) 161.16,87.39 161.16,85.54 162.69,84.02 162.69,78.63 154.53,70.47 144.4,70.47 143.38,69.46 143.38,56.26 138.63,51.51 138.63,41.47 v2(138.81,41.29)
  BOTTOM w0.127: v2(161.16,87.39) 160.15,87.39 159.77,87.77 159.77,97.3 160.86,98.39 162.51,98.39 163.21,99.09 163.21,101.57 163.72,102.07 163.72,103.77 164.72,104.78 164.72,106.33 165.17,106.78 166.72,106.78 v1(166.81,106.87) ; J48.2 150.74,26.95 137.86,26.95 134.37,23.46 129.79,23.46 128.35,24.91 128.35,35.45 133.68,40.78 137.24,40.78 137.75,41.29 v2(138.81,41.29)
SOC_MMC0_CLK: length 23.4
  TOP w0.127: v2(197.33,115) 196.58,115.75 R436.2 ; U1.F13 v1(178.81,118.61)
  L03_SIG1 w0.127: v2(197.33,115) 195.06,115 194.93,115.13 194.93,115.35 194.81,115.48 194.55,115.48 194.43,115.35 194.43,115.13 194.3,115 192.45,115 190.57,116.88 186.79,116.88 184.94,118.73 183.97,118.73 183.45,118.21 180.79,118.21 179.98,119.01 U1.F13 v1(178.81,118.61)
SOC_MMC0_CLK_R: length 137.4
  TOP w0.127: J37.5 v2(238.09,24.54) 238.09,25.21 238.28,25.4 R242.1 ; v2(198.93,115.89) 198.73,116.09 R436.1
  L08_SIG2 w0.127: v2(240.72,29.81) 238.79,29.81 238.23,29.25 236.44,29.25 235.24,30.45 235.24,32.41 229.52,38.14 227.56,38.14 226.85,38.85 226.85,40.81 226.13,41.53 226.13,41.85 226.13,41.85 226.13,46.34 226.12,46.34 226.12,50.27 225.27,51.12 225.27,63.68 226.5,64.91 226.5,68.7 224.87,70.34 224.87,78.23 226.97,80.34 226.97,87.31 224.89,89.4 223.1,89.4 222.56,88.85 222.45,88.85 222.44,88.84 222.06,88.84 222.05,88.85 219.15,88.85 219.14,88.84 218.76,88.84 218.75,88.85 218.64,88.85 218.17,89.32 218.17,89.32 216.32,91.18 215.89,91.18 215.63,91.45 215.63,92.69 215.29,93.03 215.29,97.51 210.86,101.94 210.86,106.72 210.9,106.76 210.9,108.13 210.48,108.54 210.48,108.72 209.9,109.31 209.78,109.31 209.3,109.79 209.3,109.81 208.43,110.68 206.75,110.68 205.99,111.44 205.99,114.62 205.44,115.18 205.03,115.18 204.9,115.31 204.9,116.78 204.77,116.91 204.52,116.91 204.39,116.78 204.39,115.46 204.11,115.18 203.3,115.18 203.17,115.31 203.17,116.6 203.05,116.73 202.79,116.73 202.66,116.6 202.66,115.31 202.54,115.18 201.7,115.18 200.79,116.09 199.14,116.09 v2(198.93,115.89)
  BOTTOM w0.127: U111.3 240.33,30.19 v2(240.72,29.81) 240.72,27.9 238.09,25.28 v2(238.09,24.54)
SOC_MMC0_CMD: length 17.4
  TOP w0.127: R432.2 196.33,117.62 196.04,117.62 195.68,117.97 v2(195.68,118.66) ; U1.C13 v1(182.01,119.41)
  L08_SIG2 w0.102: v1(182.01,119.41) 182.98,119.41 183.46,119.9 187.58,119.9 187.83,119.65 189.1,119.65
  L08_SIG2 w0.127: 189.1,119.65 191.12,119.65 192.89,117.87 194.89,117.87 v2(195.68,118.66)
SOC_MMC0_CMD_R: length 145.4
  TOP w0.127: J37.3 v2(240.29,24.54) ; v2(209.5,114.42) 209.06,114.86 209.06,115.04 209.55,115.53 209.55,115.71 209.37,115.89 209.19,115.89 208.7,115.4 208.52,115.4 208.13,115.78 208.13,115.96 208.75,116.58 208.75,116.76 208.57,116.94 208.39,116.94 207.77,116.32 207.59,116.32 207.09,116.83 206.5,116.83 206.37,116.7 206.37,115.71 206.24,115.58 205.99,115.58 205.86,115.71 205.86,116.7 205.74,116.83 205.48,116.83 205.36,116.7 205.36,115.71 205.23,115.58 204.97,115.58 204.85,115.71 204.85,116.7 204.72,116.83 200.38,116.83 199.85,117.36 R432.1
  L03_SIG1 w0.127: v2(236.85,30.42) 237.24,30.04 237.24,28.34 240.29,25.28 v2(240.29,24.54)
  L08_SIG2 w0.127: v2(209.5,114.42) 209.5,112.74 212.14,110.1 212.14,109.73 212.27,109.61 212.48,109.61 212.61,109.48 212.61,109.22 212.48,109.1 212.27,109.1 212.14,108.97 212.14,108.72 212.27,108.59 212.48,108.59 212.61,108.46 212.61,108.21 212.48,108.08 212.27,108.08 212.14,107.95 212.14,107.7 212.27,107.57 212.48,107.57 212.61,107.45 212.61,107.19 212.48,107.07 212.27,107.07 212.14,106.94 212.14,106.68 212.27,106.56 212.48,106.56 212.61,106.43 212.61,106.18 212.48,106.05 212.27,106.05 212.14,105.92 212.14,105.67 212.27,105.54 212.48,105.54 212.61,105.41 212.61,105.16 212.48,105.03 212.27,105.03 212.14,104.91 212.14,103.97 212.27,103.84 212.48,103.84 212.61,103.71 212.61,103.46 212.48,103.33 212.27,103.33 212.14,103.21 212.14,102.38 212.98,101.54 213.16,101.54 213.48,101.86 213.66,101.86 213.84,101.68 213.84,101.5 213.52,101.18 213.52,101 213.7,100.82 213.88,100.82 214.2,101.14 214.38,101.14 214.56,100.96 214.56,100.78 214.24,100.46 214.24,100.29 214.42,100.11 214.6,100.11 214.92,100.43 215.1,100.43 215.28,100.25 215.28,100.07 214.96,99.75 214.96,99.57 215.14,99.39 215.32,99.39 215.64,99.71 215.82,99.71 215.99,99.53 215.99,99.35 215.67,99.03 215.67,98.85 216.51,98.01 216.51,93.49 218.41,91.58 224.79,91.58 226.62,89.75 226.62,89.41 228.27,87.76 228.27,79.95 225.97,77.65 225.97,71.6 227.61,69.97 227.61,63.05 226.45,61.89 226.45,51.74 227.88,50.31 227.88,46.86 228.45,46.29 229.03,46.29 230.37,44.96 230.37,41.1 230.54,40.92 230.55,40.92 232,39.48 232,39.32 232.95,38.37 232.95,37.32 234.06,36.21 235.27,36.21 236.63,34.85 236.63,32.02 237.21,31.43 237.21,30.83 236.85,30.47 v2(236.85,30.42)
  BOTTOM w0.127: U111.6 237.66,29.69 236.93,30.42 v2(236.85,30.42) 236.88,30.39 236.88,29.4 236.4,28.92 R780.1
SOC_MMC0_DAT0: length 12.5
  TOP w0.127: R427.2 190.85,115.23 190.73,115.35 190.73,116.51 189.6,117.64 189.6,118.42 188.19,119.83 184.45,119.83 184.04,119.41 182.81,119.41 U1.B13
SOC_MMC0_DAT0_R: length 148.9
  TOP w0.127: R427.1 195.2,115.23 195.66,114.77 195.66,113.93 196.27,113.32 198.43,113.32 198.59,113.49 204.38,113.49 204.62,113.73 206.63,113.73 207.57,112.79 v2(208.66,112.79) ; J37.7 235.89,24.73 237.06,25.9 237.06,28.41 239.47,30.83 v2(240.84,30.83)
  L08_SIG2 w0.127: v2(240.84,30.83) 240.28,30.83 240.16,30.95 240.16,31.51 240.16,31.51 240.16,32.15 240.03,32.27 239.78,32.27 239.65,32.14 239.65,30.95 239.52,30.83 239.27,30.83 239.14,30.95 239.14,31.51 239.01,31.64 238.76,31.64 238.63,31.51 238.63,30.95 238.5,30.83 237.62,30.83 237.52,30.72 237.52,30.27 237.17,29.92 236.69,29.92 235.89,30.72 235.89,33.16 235.07,33.98 234.89,33.98 234.82,33.9 234.64,33.9 234.46,34.08 234.46,34.26 234.53,34.34 234.53,34.52 234.35,34.7 234.18,34.7 234.1,34.62 233.92,34.62 233.74,34.8 233.74,34.98 233.82,35.06 233.82,35.24 233.64,35.42 233.46,35.42 233.38,35.34 233.2,35.34 233.02,35.52 233.02,35.7 233.1,35.77 233.1,35.95 232.92,36.13 232.74,36.13 232.66,36.06 232.48,36.06 232.3,36.24 232.3,36.41 232.38,36.49 232.38,36.67 231.42,37.63 231.42,38.9 229.57,40.76 229.57,41.32 229.39,41.49 227.41,41.49 227.05,41.85 227.05,42.64 227.18,42.77 228.09,42.77 228.22,42.89 228.22,43.15 228.09,43.28 227.18,43.28 227.05,43.4 227.05,44.15 227.18,44.28 227.94,44.28 228.07,44.4 228.07,44.66 227.94,44.78 227.18,44.78 227.05,44.91 227.05,45.17 227.18,45.29 227.94,45.29 228.07,45.42 228.07,45.67 227.94,45.8 227.18,45.8 227.05,45.93 227.05,50.3 225.9,51.46 225.9,62.95 227.13,64.18 227.13,69.19 225.49,70.83 225.49,77.93 227.63,80.08 227.63,87.58 225.01,90.21 224.05,90.21 223.19,91.07 218.13,91.07 215.95,93.26 215.95,97.78 211.58,102.15 211.58,109.59 208.66,112.51 v2(208.66,112.79)
  BOTTOM w0.127: R779.1 241.97,30.61 241.75,30.83 v2(240.84,30.83) 240.4,30.83 240.27,30.69 U111.2
SOC_MMC0_DAT1: length 17.1
  TOP w0.127: U1.A13 184.27,119.01 184.3,118.98 188.64,118.98 189.32,118.3 189.32,117.44 190.45,116.31 190.45,115.23 191.16,114.52 194.61,114.52 195.86,113.27 195.86,113.15 196.35,112.66 R424.2
SOC_MMC0_DAT1_R: length 142.7
  TOP w0.127: v2(240.84,31.71) 240.33,31.21 239.47,31.21 236.73,28.46 236.73,26.08 234.79,24.14 J37.8 ; v2(206.45,112.92) 205.92,112.38 205.18,112.38 204.75,112.82 204.75,113.04 204.62,113.17 204.37,113.17 204.24,113.04 204.24,112.82 204.11,112.69 203.86,112.69 203.41,113.14 198.73,113.14 198.25,112.66 R424.1
  L08_SIG2 w0.127: v2(240.84,31.71) 241.43,31.71 241.55,31.59 241.55,30.84 241.05,30.33 239.7,30.33 239.53,30.49 239.19,30.49 239.03,30.33 238.77,30.33 238.07,29.63 236.6,29.63 235.63,30.61 235.63,32.57 229.57,38.62 228.09,38.62 227.97,38.75 227.97,40.23 226.51,41.69 226.51,46.5 226.5,46.5 226.5,50.46 225.65,51.31 225.65,63.38 226.89,64.61 226.89,69.03 225.25,70.67 225.25,78.07 227.36,80.18 227.36,87.47 225.02,89.8 222.88,89.8 222.63,90.06 221.69,90.06 221.28,90.46 220.24,90.46 219.84,90.06 218.8,90.06 215.67,93.18 215.67,97.67 211.24,102.1 211.24,106.56 211.28,106.6 211.28,108.28 210.87,108.7 210.87,108.88 211.06,109.07 211.06,109.25 210.88,109.43 210.7,109.43 210.61,109.34 210.41,109.34 210.26,109.49 210.26,109.71 210.6,110.05 210.6,110.23 210.42,110.41 210.24,110.41 209.8,109.97 209.68,109.97 209.43,110.22 209.43,110.31 209.88,110.77 209.88,110.95 209.7,111.13 209.52,111.13 209.07,110.67 208.98,110.67 208.53,111.12 208.53,111.27 208.08,111.72 208.08,113.17 207.95,113.3 207.7,113.3 207.57,113.17 207.57,111.33 207.3,111.06 206.91,111.06 206.38,111.6 206.38,112.84 v2(206.45,112.92)
  BOTTOM w0.127: R777.1 241.84,31.71 v2(240.84,31.71) 240.32,31.19 U111.1
SOC_MMC0_DAT2: length 8.7
  TOP w0.127: U1.A11 189.1,120.61 189.99,119.73 R418.2
SOC_MMC0_DAT2_R: length 154.1
  TOP w0.127: J37.1 v2(242.49,24.54) ; v2(193.7,119.78) 193.65,119.73 R418.1
  L03_SIG1 w0.127: v2(237.49,31.89) 238.25,31.13 238.38,31.13 239.8,29.71 239.8,27.88 242.49,25.19 v2(242.49,24.54) ; v2(193.7,119.78) 194.14,119.78 194.74,120.37 197.02,120.37 198.26,119.13 198.26,118.99 198.47,118.78 198.47,118.72 198.74,118.45 198.74,118.43 199.01,118.43 199.62,117.82 200.84,117.82 201.55,117.11 209.58,117.11 209.63,117.16 v2(210.11,117.16)
  L08_SIG2 w0.127: v2(210.11,117.16) 210.44,116.83 210.44,114.2 210.41,114.17 210.41,113.8 210.44,113.77 210.44,112.44 211.28,111.6 211.46,111.6 212.09,112.23 212.27,112.23 212.45,112.05 212.45,111.87 211.81,111.24 211.81,111.06 211.99,110.88 212.17,110.88 212.81,111.51 212.99,111.51 213.17,111.33 213.17,111.15 212.53,110.52 212.53,110.34 212.98,109.9 213.25,109.9 213.37,109.77 213.37,109.51 213.25,109.39 212.98,109.39 212.85,109.26 212.85,109.01 212.98,108.88 213.25,108.88 213.37,108.75 213.37,108.5 213.25,108.37 212.98,108.37 212.85,108.24 212.85,107.99 212.98,107.86 213.25,107.86 213.37,107.74 213.37,107.48 213.25,107.36 212.98,107.36 212.85,107.23 212.85,106.97 212.98,106.85 213.25,106.85 213.37,106.72 213.37,106.47 213.25,106.34 212.98,106.34 212.85,106.21 212.85,105.96 212.98,105.83 213.25,105.83 213.37,105.7 213.37,105.45 213.25,105.32 212.98,105.32 212.85,105.2 212.85,104.94 212.98,104.82 213.25,104.82 213.37,104.69 213.37,104.43 213.25,104.31 212.98,104.31 212.85,104.18 212.85,103.93 212.98,103.8 213.25,103.8 213.37,103.67 213.37,103.42 213.25,103.29 212.98,103.29 212.85,103.16 212.85,103.01 213.09,102.78 213.27,102.78 213.91,103.42 214.09,103.42 214.27,103.24 214.27,103.06 213.63,102.42 213.63,102.24 213.81,102.06 213.99,102.06 214.63,102.7 214.81,102.7 214.99,102.52 214.99,102.34 214.35,101.7 214.35,101.52 214.53,101.34 214.71,101.34 215.35,101.98 215.53,101.98 215.71,101.8 215.71,101.63 215.06,100.98 215.06,100.8 216.79,99.07 216.79,93.6 218.56,91.84 224.97,91.84 227.03,89.78 227.03,89.4 227.41,89.02 227.59,89.02 227.95,89.38 228.13,89.38 228.31,89.2 228.31,89.02 227.95,88.66 227.95,88.48 228.55,87.88 228.55,79.85 226.21,77.51 226.21,72.04 227.88,70.37 227.88,62.93 226.76,61.8 226.76,52.53 228.85,50.43 229.31,49.98 229.31,46.5 231.39,44.41 231.39,40.65 232.41,39.64 232.41,39.39 233.43,38.37 233.43,37.35 234.33,36.45 235.37,36.45 236.87,34.95 236.87,33.91 237.49,33.29 v2(237.49,31.89)
  BOTTOM w0.127: U111.8 237.94,30.69 237.49,31.15 v2(237.49,31.89) 236.59,31.89 236.51,31.97 R776.1
SOC_MMC0_DAT3: length 14.5
  TOP w0.127: R421.2 196.1,119.17 195.82,119.44 195.31,119.44 194.88,119.01 194.01,119.01 193.84,118.85 190.46,118.85 190.29,119.02 189.48,119.02 188.39,120.11 184,120.11 183.71,119.81 U1.A12
SOC_MMC0_DAT3_R: length 147.3
  TOP w0.127: v2(207.59,118) 206.43,119.17 199.44,119.17 199.16,118.89 198.77,118.89 198.5,119.15 198.5,119.17 R421.1 ; J37.2 v2(241.39,24.54)
  L03_SIG1 w0.127: v2(236.68,31.23) 237.26,31.23 238.38,30.11 238.38,28 241.39,24.99 v2(241.39,24.54)
  L08_SIG2 w0.127: v2(207.59,118) 207.59,116.74 207.72,116.61 208.01,116.61 208.14,116.74 208.14,116.98 208.27,117.11 208.52,117.11 208.65,116.98 208.65,116.74 208.77,116.61 209.8,116.61 209.93,116.48 209.93,116.23 209.8,116.1 208.88,116.1 208.75,115.98 208.75,114.95 208.63,114.82 208.37,114.82 208.24,114.95 208.24,115.98 208.12,116.1 207.72,116.1 207.59,115.98 207.59,115.85 207.47,115.72 207.01,115.72 206.88,115.85 206.88,118.12 206.76,118.25 206.5,118.25 206.38,118.12 206.38,115.85 206.25,115.72 205.99,115.72 205.87,115.6 205.87,115.34 206.01,115.2 207.48,115.2 207.59,115.09 207.59,114.62 207.96,114.26 207.96,114.08 207.88,114 207.88,113.82 208.06,113.64 208.24,113.64 208.32,113.72 208.5,113.72 209.14,113.07 209.14,112.61 211.86,109.9 211.86,102.27 216.23,97.9 216.23,93.37 218.27,91.33 224.65,91.33 226.31,89.66 226.31,89.32 227.91,87.72 227.91,79.97 225.73,77.79 225.73,71.34 227.37,69.7 227.37,63.2 226.17,62.01 226.17,51.61 227.61,50.18 227.61,46.73 228.32,46.01 228.85,46.01 230.05,44.82 230.05,44.24 229.92,44.12 229.36,44.12 229.23,43.99 229.23,43.74 229.36,43.61 229.92,43.61 230.05,43.48 230.05,40.88 231.8,39.13 231.8,37.91 234.31,35.4 234.31,35.19 234.57,34.94 234.77,34.94 236.22,33.49 236.22,31.69 v2(236.68,31.23)
  BOTTOM w0.127: R778.1 235.52,30.99 235.77,31.23 v2(236.68,31.23) 236.75,31.23 237.54,30.44 237.67,30.44 237.92,30.19 U111.7
SOC_MMC0_SDCD: length 161.1
  TOP w0.127: U1.F12 v1(178.81,119.41) ; R577.1 231.72,25.75 v2(232.75,25.75) U107.3 233.74,24.53 233.69,24.48 J37.9
  L03_SIG1 w0.127: v2(232.75,25.75) 235.97,28.97 235.97,31.64 236.73,32.4 237.87,32.4 v2(238.25,32.02)
  L08_SIG2 w0.102: v1(178.81,119.41) 178.81,119.27 179.07,119.01 180.09,119.01 180.59,119.52 180.59,120.14 181.05,120.59 184.22,120.59 184.28,120.54 188.34,120.54 188.47,120.41 189.1,120.41
  L08_SIG2 w0.127: v2(208.28,117.57) 209.12,117.57 209.42,117.87 210.57,117.87 213.61,114.82 213.61,105.04 217.3,101.36 217.3,94.76 219.84,92.21 225.05,92.21 227.46,89.8 228.22,89.8 229.49,88.53 229.49,85.61 228.85,84.98 228.85,79.81 226.49,77.45 226.49,72.1 228.08,70.51 228.08,70.51 228.35,70.24 228.35,62.75 227.08,61.48 227.08,52.59 229.74,49.93 229.74,46.75 231.9,44.59 231.9,41.54 231.93,41.52 231.93,41.5 232.2,41.23 232.22,41.23 234.06,39.38 234.06,37.86 234.38,37.54 234.57,37.73 235.08,37.73 235.33,37.48 235.33,36.97 235.86,36.97 237.01,35.83 237.74,35.83 238.25,35.32 v2(238.25,32.02) ; v2(209.8,121.81) 209.74,121.87 203.85,121.87 203.48,121.5 198.07,121.5 196.98,120.41 189.1,120.41
  BOTTOM w0.127: v2(209.8,121.81) 209.8,119.78 208.28,118.25 v2(208.28,117.57)
SOC_MMC1_CLK: length 15.9
  TOP w0.127: R388.2 179.2,137.56 v2(179.45,137.3) ; U1.J4 v1(176.41,126.61)
  L03_SIG1 w0.102: 178.23,134.89 176.8,133.45 176.8,129.81 176.43,129.44 176.43,127.95 176.78,127.6 176.8,127.6 176.8,127.23 176.41,126.84 v1(176.41,126.61)
  L03_SIG1 w0.127: v2(179.45,137.3) 178.23,136.08 178.23,134.89
  BOTTOM w0.127: v2(179.45,137.3) 179.9,137.3 180.47,137.87 R713.2
SOC_MMC1_CLK_R: length 77.3
  TOP w0.127: v2(179.32,140.77) 179.2,140.64 R388.1
  L03_SIG1 w0.127: v2(176.65,196.42) 177.15,196.42 177.6,196.86 178.66,196.86 180.7,194.83 180.7,178.2 183.69,175.2 183.69,169.64 179.91,165.85 179.91,164.62 179.93,164.59 181.36,164.59 181.48,164.47 181.48,164.21 181.36,164.09 179.93,164.09 179.81,163.96 179.81,163.71 179.93,163.58 181.36,163.58 181.48,163.45 181.48,163.2 181.36,163.07 179.93,163.07 179.81,162.94 179.81,162.69 179.93,162.56 181.36,162.56 181.48,162.44 181.48,162.18 181.36,162.05 179.93,162.05 179.81,161.93 179.81,161.67 179.93,161.55 181.36,161.55 181.48,161.42 181.48,161.17 181.36,161.04 180.05,161.04 179.81,160.8 179.81,145.02 178.31,143.52 178.31,141.79 v2(179.32,140.77)
  BOTTOM w0.127: R681.1 v2(176.65,196.42)
SOC_MMC1_CMD: length 14.1
  TOP w0.127: U1.J2 176.41,128.21 176.41,133.36 176.12,133.64 176.12,136.13 177.2,137.21 v2(178.31,137.21) 177.93,137.59 R387.2
  BOTTOM w0.127: R714.2 178.94,137.85 v2(178.31,137.21)
SOC_MMC1_CMD_R: length 78.9
  TOP w0.127: R287.1 v2(178.43,196.34) ; R387.1 v2(177.93,140.7)
  L03_SIG1 w0.127: v2(178.43,196.34) 178.74,196.02 178.74,195.67 178.74,195.67 178.74,184.19 178.26,183.71 178.26,176.93 179.48,175.71 182.27,175.71 183.31,174.67 183.31,169.86 179.53,166.08 179.53,164.61 179.4,164.48 177.55,164.48 177.42,164.36 177.42,164.1 177.55,163.98 179.1,163.98 179.17,163.9 179.17,163.54 179.1,163.47 177.55,163.47 177.42,163.34 177.42,163.09 177.55,162.96 179.15,162.96 179.3,162.81 179.3,162.52 179.23,162.45 177.55,162.45 177.42,162.32 177.42,162.07 177.55,161.94 179.2,161.94 179.32,161.82 179.32,161.53 179.23,161.44 177.55,161.44 177.42,161.31 177.42,161.05 177.55,160.93 179.22,160.93 179.43,160.72 179.43,145.4 177.93,143.91 v2(177.93,140.7)
  BOTTOM w0.127: R287.1 v2(178.43,196.34)
SOC_MMC1_DAT0: length 28.5
  TOP w0.127: U1.H3 v1(177.21,127.41) ; v2(183.06,140.3) 183.59,139.77 RA6.1
  L03_SIG1 w0.102: v1(177.21,127.41) 177.21,127.58 176.76,128.03 176.76,128.82 177.28,129.34 177.33,129.34 177.65,129.66 177.65,133.91 178.63,134.89
  L03_SIG1 w0.127: v2(183.06,140.3) 182.61,140.3 180.73,138.42 180.73,137 178.63,134.89
  BOTTOM w0.127: RA15.1 185.7,139.77 186.09,140.16 186.65,140.16 187.35,140.86 187.35,141.77 186.97,142.15 186.31,142.15 186.16,142.31 186.16,142.99 185.95,143.2 183.64,143.2 182.95,142.5 182.95,140.85 183.06,140.74 v2(183.06,140.3)
SOC_MMC1_DAT0_R: length 73
  TOP w0.127: R292.1 v2(179.95,171.93) ; v2(184,142.35) 183.9,142.25 183.65,142.25 183.26,141.86 183.26,141.29 183.87,140.68 RA6.8
  L03_SIG1 w0.127: v2(184,142.35) 184.15,142.51 184.15,143.29 185.91,145.05 189.1,145.05 194.18,150.13 199.64,150.13 200.53,149.24 201.97,149.24 202.32,149.6 202.32,159.51 196.29,165.55 v2(196.29,166.18)
  BOTTOM w0.127: v2(179.95,171.93) 179.95,171.22 179.35,170.63 R688.2 180.65,168.79 180.83,168.79 181.52,169.47 181.7,169.47 181.88,169.29 181.88,169.12 181.19,168.43 181.19,168.25 181.37,168.07 181.55,168.07 182.23,168.76 182.41,168.76 182.59,168.58 182.59,168.4 181.91,167.71 181.91,167.53 182.09,167.35 182.26,167.35 182.95,168.04 183.13,168.04 183.31,167.86 183.31,167.68 182.62,166.99 182.62,166.81 183.25,166.18 v2(196.29,166.18)
SOC_MMC1_DAT1: length 23.9
  TOP w0.127: v2(186.18,139.12) 185.23,138.17 183.87,138.17 183.44,138.6 183.44,139.13 183.57,139.26 184.25,139.26 184.53,139.54 RA6.2 ; U1.F5 v1(179.61,125.81)
  L03_SIG1 w0.102: v1(179.61,125.81) 180.01,126.21 180.01,129.22 180.8,130.01 180.8,132.68 183.01,134.89
  L03_SIG1 w0.127: 183.01,134.89 186.02,137.9 186.02,139.05 186.13,139.16 186.19,139.1 186.23,139.1 186.23,139.15 186.18,139.15 v2(186.18,139.12)
  BOTTOM w0.127: RA15.2 185.04,139.32 185.24,139.12 v2(186.18,139.12)
SOC_MMC1_DAT1_R: length 67.8
  TOP w0.127: v2(177.79,170.63) 177.79,171.66 177.52,171.93 R281.1 ; RA6.7 184.53,140.99 184.25,141.26 184.25,141.9 184.65,142.29 v2(184.65,142.65)
  L03_SIG1 w0.127: v2(197.36,165.67) 202.6,160.43 202.6,149.41 202.06,148.86 200.41,148.86 199.64,149.62 194.16,149.62 188.51,143.97 185.97,143.97 v2(184.65,142.65)
  BOTTOM w0.127: v2(197.36,165.67) 181.38,165.67 176.9,170.15 R682.2 v2(177.79,170.63)
SOC_MMC1_DAT2: length 21.1
  TOP w0.127: U1.J5 v1(177.21,125.81) ; RA6.3 185.04,139.38 v2(184.63,138.98)
  L08_SIG2 w0.102: 177.62,128.95 177.62,128.06 177.63,128.04 177.42,127.83 177.01,127.83 176.81,127.62 176.81,126.21 v1(177.21,125.81)
  L08_SIG2 w0.127: 177.62,128.95 179.28,130.6 179.28,132.62 179.27,132.62 179.27,133.49 179.28,133.5 179.28,134.21 181.18,136.11 181.18,138.14 182.04,139 183.25,139 183.63,139.38 184.23,139.38 v2(184.63,138.98)
  BOTTOM w0.127: RA15.3 184.53,139.21 184.63,139.11 v2(184.63,138.98)
SOC_MMC1_DAT2_R: length 71.6
  TOP w0.127: RA6.6 185.04,141.11 185.24,141.32 185.24,142.2 v2(185.69,142.65) ; R269.1 175.11,171.79 v2(174.24,171.79)
  L03_SIG1 w0.127: v2(197.31,166.66) 202.88,161.09 202.88,149.23 201.45,147.79 193.55,147.79 189.41,143.65 186.69,143.65 v2(185.69,142.65)
  BOTTOM w0.127: v2(197.31,166.66) 197.87,166.11 197.87,165.42 197.56,165.11 180.47,165.11 175.25,170.33 R679.2 174.71,170.63 174.24,171.1 v2(174.24,171.79)
SOC_MMC1_DAT3: length 20.4
  TOP w0.127: RA6.4 185.69,139.32 184.78,138.42 184.27,138.42 v2(183.95,138.73) ; U1.H4 v1(177.21,126.61)
  L08_SIG2 w0.102: v1(177.21,126.61) 177.59,127 177.59,127.62 177.8,127.83 178.28,127.83 178.41,127.95 178.41,129.34
  L08_SIG2 w0.127: v2(183.95,138.73) 183.95,138.72 182.42,138.72 181.69,137.99 181.69,136.24 179.55,134.1 179.55,130.48 178.41,129.34
  BOTTOM w0.127: RA15.4 183.88,139.32 183.95,139.26 v2(183.95,138.73)
SOC_MMC1_DAT3_R: length 73.2
  TOP w0.127: RA6.5 185.7,140.68 186.23,141.21 186.23,142.15 v2(186.73,142.65)
  L03_SIG1 w0.127: v2(198.3,166.69) 198.3,166.61 203.16,161.75 203.16,149.1 201.57,147.51 193.67,147.51 189.51,143.35 187.43,143.35 v2(186.73,142.65)
  BOTTOM w0.127: R695.2 R304.1 181.71,171.93 184.05,169.59 184.23,169.59 185.17,170.52 185.35,170.52 185.53,170.34 185.53,170.16 184.59,169.23 184.59,169.05 184.77,168.87 184.95,168.87 185.89,169.8 186.07,169.8 186.25,169.62 186.25,169.44 185.31,168.51 185.31,168.33 185.49,168.15 185.67,168.15 186.61,169.08 186.79,169.08 186.97,168.9 186.97,168.72 186.03,167.79 186.03,167.61 186.29,167.35 187.43,167.35 187.56,167.48 187.56,167.91 187.69,168.04 187.94,168.04 188.07,167.91 188.07,167.48 188.2,167.35 195.17,167.35 195.35,167.17 197.82,167.17 v2(198.3,166.69)
SOC_MMC1_DAT4: length 93.1
  TOP w0.127: v2(190.12,169.18) 189.43,169.18 188.87,168.62 183.11,168.62 182.98,168.75 182.98,169.15 182.85,169.28 182.6,169.28 182.47,169.15 182.47,168.75 182.35,168.62 182.09,168.62 181.96,168.75 181.96,169.15 181.84,169.28 181.58,169.28 181.46,169.15 181.46,168.75 181.33,168.62 180.95,168.62 180.7,168.87 180.7,172.28 v2(179.19,173.79) 178.58,173.79 178.43,173.94 178.43,175.98 178.57,176.12 R299.1 ; U1.E3 v1(179.61,127.41)
  L08_SIG2 w0.102: 181.89,126.66 181.43,126.2 180.24,126.2 180.01,126.43 180.01,126.79 179.61,127.19 v1(179.61,127.41)
  L08_SIG2 w0.127: v2(190.12,169.18) 190.91,168.39 190.91,168.06 191.03,167.94 191.64,167.94 191.77,167.81 191.77,167.56 191.64,167.43 191.03,167.43 190.91,167.3 190.91,167.05 191.03,166.92 191.64,166.92 191.77,166.79 191.77,166.54 191.64,166.41 191.03,166.41 190.91,166.29 190.91,166.03 191.03,165.9 191.64,165.9 191.77,165.78 191.77,165.52 191.64,165.4 191.03,165.4 190.91,165.27 190.91,164.72 191.03,164.59 191.4,164.59 191.53,164.47 191.53,164.21 191.4,164.09 191.03,164.09 190.91,163.96 190.91,163.71 191.03,163.58 191.4,163.58 191.53,163.45 191.53,163.2 191.4,163.07 191.03,163.07 190.91,162.94 190.91,162.69 191.03,162.56 191.4,162.56 191.53,162.44 191.53,162.18 191.4,162.05 191.03,162.05 190.91,161.93 190.91,161.67 191.03,161.55 191.4,161.55 191.53,161.42 191.53,161.17 191.4,161.04 191.03,161.04 190.91,160.91 190.91,160.66 191.03,160.53 191.4,160.53 191.53,160.4 191.53,160.15 191.4,160.02 191.03,160.02 190.91,159.9 190.91,159.64 191.03,159.51 191.4,159.51 191.53,159.39 191.53,159.13 191.4,159.01 191.03,159.01 190.91,158.88 190.91,158.63 191.03,158.5 191.4,158.5 191.53,158.37 191.53,158.12 191.4,157.99 191.03,157.99 190.91,157.86 190.91,157.61 191.03,157.48 191.4,157.48 191.53,157.36 191.53,157.1 191.4,156.97 191.03,156.97 190.91,156.85 190.91,156.59 191.03,156.47 191.4,156.47 191.53,156.34 191.53,156.09 191.4,155.96 191.03,155.96 190.91,155.83 190.91,155.58 191.03,155.45 191.4,155.45 191.53,155.32 191.53,155.07 191.4,154.94 191.03,154.94 190.91,154.82 190.91,153.33 190.75,153.18 190.75,153.15 190.26,152.65 190.26,152.47 190.57,152.16 190.57,151.98 190.39,151.8 190.21,151.8 189.9,152.11 189.72,152.11 189.54,151.93 189.54,151.75 189.85,151.44 189.85,151.26 189.67,151.08 189.49,151.08 189.18,151.39 189,151.39 188.82,151.21 188.82,151.03 189.13,150.72 189.13,150.54 188.95,150.36 188.77,150.36 188.46,150.68 188.28,150.68 188.1,150.5 188.1,150.32 188.41,150 188.41,149.82 188.24,149.64 188.06,149.64 187.74,149.96 187.56,149.96 184.78,147.18 184.78,144.25 186.23,142.8 186.23,141.31 187.71,139.84 187.71,138.17 183.18,133.64 183.18,131.87 182.48,131.16 182.48,127.25 181.89,126.66
  BOTTOM w0.127: R691.2 v2(179.19,173.79)
SOC_MMC1_DAT5: length 91.3
  TOP w0.127: U1.G4 v1(178.01,126.61) ; v2(182.62,173.82) 181.98,173.82 181.86,173.94 181.86,175.9 182.07,176.12 R286.1
  L08_SIG2 w0.102: 178.31,130.04 176,127.73 176,125.62 176.2,125.41 177.39,125.41 177.62,125.64 177.62,126.23 v1(178.01,126.61)
  L08_SIG2 w0.127: 178.31,130.04 178.31,133.87 180.86,136.43 180.86,138.69 182.4,140.22 182.4,143.42 183.67,144.69 183.67,157.22 183.79,157.35 186.05,157.35 186.18,157.48 186.18,157.73 186.05,157.86 183.79,157.86 183.67,157.98 183.67,158.24 183.79,158.37 186.05,158.37 186.18,158.49 186.18,158.75 186.05,158.87 183.79,158.87 183.67,159 183.67,159.25 183.79,159.38 186.05,159.38 186.18,159.51 186.18,159.76 186.05,159.89 183.79,159.89 183.67,160.02 183.67,160.27 183.79,160.4 186.05,160.4 186.18,160.52 186.18,160.78 186.05,160.91 183.79,160.91 183.67,161.03 183.67,161.29 183.79,161.41 186.05,161.41 186.18,161.54 186.18,161.79 186.05,161.92 183.79,161.92 183.67,162.05 183.67,163.69 187.93,167.95 188.14,167.95 189.95,169.76 v2(189.95,170.58)
  BOTTOM w0.127: v2(189.95,170.58) 188.96,171.57 184.87,171.57 v2(182.62,173.82) R685.2
SOC_MMC1_DAT6: length 92.4
  TOP w0.127: U1.F4 v1(178.81,126.61) ; 175.62,173.82 173.74,171.93 173.74,171.46 174.62,170.58 174.62,169.07 175.39,168.31 189.35,168.31 v2(189.66,168.62) ; 175.62,173.82 v2(175.63,173.82) ; 175.62,173.82 175,173.82 174.87,173.94 174.87,175.98 175.01,176.12 R271.1
  L08_SIG2 w0.102: v1(178.81,126.61) 178.81,126.77 178.42,127.16 178.42,127.6 178.62,127.8 178.99,127.8 179.29,128.1 179.84,128.1 180.14,127.8 181.39,127.8
  L08_SIG2 w0.127: 181.39,127.8 181.63,128.04 181.63,128.47 180.8,129.3 180.8,134.33 182.19,135.73 182.83,135.73 185.52,138.42 185.52,140.05 184.45,141.11 183.51,141.11 183.13,141.49 183.13,143.3 184.23,144.39 184.23,147.41 188.06,151.25 188.06,158.35 187.93,158.48 186.69,158.48 186.56,158.6 186.56,158.86 186.69,158.98 187.93,158.98 188.06,159.11 188.06,159.37 187.93,159.49 186.69,159.49 186.56,159.62 186.56,159.87 186.69,160 187.93,160 188.06,160.13 188.06,160.38 187.93,160.51 186.69,160.51 186.56,160.64 186.56,160.89 186.69,161.02 187.93,161.02 188.06,161.14 188.06,161.4 187.93,161.52 186.69,161.52 186.56,161.65 186.56,161.91 186.69,162.03 187.93,162.03 188.06,162.16 188.06,162.41 187.93,162.54 186.69,162.54 186.56,162.67 186.56,162.92 186.69,163.05 187.93,163.05 188.06,163.18 188.06,167.02 v2(189.66,168.62)
  BOTTOM w0.127: R680.2 v2(175.63,173.82)
SOC_MMC1_DAT7: length 92.5
  TOP w0.127: R260.1 173.62,176.12 173.4,175.9 v2(173.4,173.82) 173.4,171.17 174.24,170.32 174.24,168.9 175.39,167.76 187.73,167.76 v2(188.72,166.77) ; U1.G5 v1(178.81,125.81)
  L08_SIG2 w0.102: 181.48,127.04 181.46,127.01 180.27,127.01 180.24,127.04 180.24,127.04 180.04,127.24 180.04,127.25 180.03,127.26 180.03,127.57 180.04,127.58 180.04,127.59 179.77,127.85 179.4,127.85 179.2,127.65 179.2,126.2 v1(178.81,125.81)
  L08_SIG2 w0.127: 181.48,127.04 182.07,127.62 182.07,129 181.53,129.53 181.53,133.29 181.74,133.49 181.74,134 183.03,135.3 183.41,135.3 187.32,139.21 187.32,139.71 186.82,140.22 186.36,140.22 185.24,141.34 185.24,142.39 185.19,142.44 185.19,142.8 184.51,143.49 184.51,147.3 188.34,151.13 188.34,151.14 188.98,151.78 188.98,157.99 189.1,158.12 190.12,158.12 190.25,158.25 190.25,158.5 190.12,158.63 189.1,158.63 188.98,158.76 188.98,159.01 189.1,159.14 190.12,159.14 190.25,159.26 190.25,159.52 190.12,159.64 189.1,159.64 188.98,159.77 188.98,160.03 189.1,160.15 190.12,160.15 190.25,160.28 190.25,160.53 190.12,160.66 189.1,160.66 188.98,160.79 188.98,161.04 189.1,161.17 190.12,161.17 190.25,161.3 190.25,161.55 190.12,161.68 189.1,161.68 188.98,161.8 188.98,162.06 189.1,162.18 190.12,162.18 190.25,162.31 190.25,162.57 190.12,162.69 189.1,162.69 188.98,162.82 188.98,163.07 189.1,163.2 190.12,163.2 190.25,163.33 190.25,163.58 190.12,163.71 189.1,163.71 188.98,163.84 188.98,164.09 189.1,164.22 190.12,164.22 190.25,164.34 190.25,164.6 190.12,164.72 189.1,164.72 188.98,164.85 188.98,166.07 188.72,166.32 v2(188.72,166.77)
  BOTTOM w0.127: v2(173.4,173.82) 173.4,174.65 173.56,174.82 R673.2
SOC_MMC1_SDWP: length 86.7
  TOP w0.127: U1.K3 v1(175.61,127.41)
  L03_SIG1 w0.127: v2(174.33,199.49) 175.19,198.62 177.47,198.62 189.23,186.86 v2(189.23,169.89)
  L08_SIG2 w0.102: 177.93,129.99 175.61,127.67 v1(175.61,127.41)
  L08_SIG2 w0.127: 177.93,129.99 177.93,133.87 180.62,136.57 180.62,138.84 182.12,140.34 182.12,143.73 183.39,145 183.39,164.05 v2(189.23,169.89)
  BOTTOM w0.127: R676.1 v2(174.33,199.49)
SOC_NMIZ: length 140.1
  TOP w0.127: v1(169.21,131.15) 168.81,130.75 U1.W1 ; U24.19 89.67,185.77 v2(90.17,186.27) 89.84,186.27 89.66,186.45 R229.2
  L08_SIG2 w0.102: 168.26,134.89 168.26,132.1 v1(169.21,131.15)
  L08_SIG2 w0.127: v2(90.17,186.27) 90.57,186.68 103.23,186.68 107.67,191.12 153.94,191.12 161.8,183.27 161.8,183.22 161.89,183.13 161.89,155.99 162.37,155.51 162.37,152.98 162.08,152.69 162.08,150.17 162.28,149.97 162.28,148.26 161.8,147.78 161.8,147.03 163.02,145.81 163.02,141.68 165.98,138.73 165.98,137.14 166.43,136.69 166.49,136.69 168.26,134.92 168.26,134.89
  BOTTOM w0.127: R229.2 89.66,186.78 v2(90.17,186.27)
SOC_PCIE_RXN0: length 3
  TOP w0.127: R182.2 218.31,222.66 217.84,222.66 217.48,223.02 J5.A16
SOC_PCIE_RXN0_C: length 123.7
  TOP w0.127: R182.1 220.77,222.75 221.44,222.75 222.22,221.96 222.22,208.27 216.81,202.86 201.09,202.86 191.01,192.78 191.01,175.66 192.76,173.9 192.76,164.04 186.54,157.82 186.54,153.79 184.91,152.16 184.91,144.64 181.86,141.59 181.86,135.56 180.81,134.5 U1.D1
SOC_PCIE_RXP0: length 3
  TOP w0.127: J5.A17 217.48,222.02 217.84,222.38 218.31,222.38 R181.2
SOC_PCIE_RXP0_C: length 123.7
  TOP w0.127: R181.1 220.23,222.03 220.68,222.47 221.32,222.47 221.95,221.85 221.95,208.38 216.7,203.13 200.98,203.13 190.73,192.89 190.73,175.54 192.49,173.79 192.49,164.15 186.27,157.93 186.27,153.91 184.64,152.28 184.64,144.76 181.59,141.71 181.59,135.67 180.54,134.63 180.54,129.15 U1.E1
SOC_PCIE_TXN0: length 84.8
  TOP w0.127: C171.2 183.38,156.36 183.38,157.97 186.61,161.2 191.14,165.73 191.14,171.49 188.7,173.92 188.7,195.7 192.41,199.41 201.22,208.22 201.22,221.56 204.31,224.65 208.75,224.65 J5.B14
SOC_PCIE_TXN0_C: length 28.5
  TOP w0.127: U1.H1 177.87,128.88 177.87,134.47 180.45,137.04 180.45,142.21 183.45,145.21 183.45,153.73 C171.1
SOC_PCIE_TXP0: length 84.8
  TOP w0.127: C170.2 184.14,155.59 183.92,155.59 183.65,155.86 183.65,157.85 186.81,161.01 191.41,165.61 191.41,171.6 188.98,174.04 188.98,195.59 192.6,199.21 201.49,208.1 201.49,221.45 204.42,224.37 208.77,224.37 J5.B15
SOC_PCIE_TXP0_C: length 28.5
  TOP w0.127: C170.1 183.73,153.88 183.73,145.1 180.72,142.09 180.72,136.93 178.15,134.35 178.15,128.88 U1.G1
SOC_PCIE_WAKEN: length 296.5
  TOP w0.127: J5.B11 208.48,230.02 207.14,228.68 v2(207.14,228.11) 206.36,227.33 R802.2 ; U1.E14 v1(179.61,117.81)
  L03_SIG1 w0.102: v1(179.61,117.81) 179.18,118.24 178.97,118.24 178.97,118.23 178.65,118.23 178.64,118.24 178.6,118.24 178.41,118.43 178.41,118.79 178.18,119.01 169.75,119.01 168.85,118.11 168.85,117.43 168.4,116.98 168.4,114.46 168.03,114.08 168.03,113.66 167.79,113.43 167.39,113.43 166.57,112.61 164.69,112.61 163.07,110.99 162.71,110.99 161.97,110.25 161.21,110.25
  L03_SIG1 w0.127: 161.21,110.25 160.93,110.25 160.88,110.2 159.98,110.2 159.75,109.97 156.95,109.97 155.83,108.85 152.6,108.85 151.33,107.58 144.3,107.58 144.26,107.55 131.02,107.55 102.09,136.48 102.09,162.66 94.06,170.69 94.04,170.69 91.58,173.15 91.58,178.46 93.09,179.97 93.09,180.48 92.58,180.99 92.58,183.28 92.33,183.53 92.33,184.93 93.6,186.2 93.6,188.37 97.57,192.34 123.11,192.34 123.57,192.8 164.04,192.8 173.69,202.45 177.37,202.45 179.45,204.53 179.45,210.41 182.42,213.37 197.3,213.37 205.49,221.56 205.49,226.46 v2(207.14,228.11)
SOC_PLL_LOCK: length 309.1
  TOP w0.102: U20.B12 75.91,200.25 75.91,200.93 75.91,200.93 75.91,202.31 76.07,202.48
  TOP w0.127: 76.07,202.48 76.07,202.84 75.82,203.09 75.57,203.09 75.08,203.57 75.08,204.87 v1(75.29,205.07) ; R39.2 60.86,128.75 60.37,128.26 60.27,128.26 58.87,126.86 v2(53.47,126.86) ; U1.N5 v1(174.01,125.01)
  L03_SIG1 w0.102: v1(174.01,125.01) 174.42,125.43 174.42,127.95 174.73,128.26 174.73,134.89
  L03_SIG1 w0.127: v1(75.29,205.07) 75.13,204.92 72.82,204.92 72.69,205.04 70.84,205.04 69.85,206.03 61.36,206.03 58.21,202.88 57.46,202.88 55.5,204.85 55.5,205.75 v2(54.99,206.26) ; 174.73,134.89 174.73,137.07 173.2,138.6 173.2,140.7 174.18,141.68 174.18,141.68 174.82,142.32 174.82,142.32 174.89,142.39 174.89,142.59 174.89,144.19 176.35,145.65 176.35,149.49 175.08,150.76 175.08,166.31 174.65,166.74 174.65,170.03 171.58,173.1 171.58,180.46 174.54,183.42 174.54,192.79 172.78,194.54 170.41,194.54 168.91,193.04 168.91,191.4 165.86,188.36 126.24,188.36 124.47,186.59 115.18,186.59 114.1,187.67 97.71,187.67 v2(97.64,187.75)
  L08_SIG2 w0.127: v2(97.64,187.75) 94.02,187.75 90.77,191 90.03,191 89.57,191.45 89.57,193.77 89.41,193.93 89.41,196.68 88.8,197.29 88.8,198.52 87.06,200.26 86.2,200.26 86.19,200.27 85.71,200.27 84.8,201.18 83.81,201.18 80.12,204.87 75.49,204.87 v1(75.29,205.07)
  BOTTOM w0.127: v2(53.47,126.86) 55.52,128.92 55.52,170.09 57.24,171.81 57.24,181.43 55.63,183.04 55.63,205.63 v2(54.99,206.26)
SOC_PORZ: length 129
  TOP w0.127: U26.4 103.14,178.82 v2(103.51,178.45) R259.2 ; U1.AA3 v1(167.61,127.41)
  L08_SIG2 w0.102: v1(167.61,127.41) 167.61,128.52 164.43,131.7 164.43,134.89
  L08_SIG2 w0.127: 164.43,134.89 164.43,136.06 161.12,139.36 161.12,144.96 160.54,145.54 160.54,149.63 160.72,149.81 160.72,152.69 161.4,153.38 161.4,155.11 160.9,155.62 160.9,169.84 160.45,170.28 160.45,183.04 153.48,190.01 110.78,190.01 105.75,184.98 105.75,184.89 105.71,184.85 105.71,180.66 v2(103.51,178.45)
SOC_QSPI_CLK: length 11.5
  TOP w0.127: U1.K25 176.01,108.35 175.94,108.28 175.94,105.51 177.67,103.77 179.48,103.77 181.38,101.87 R463.2
SOC_QSPI_CLK_R: length 47.2
  TOP w0.127: v2(183.92,97.91) 182.58,97.91 181.38,99.1 R463.1 ; v2(202.95,83.83) 201.55,83.83 201.28,83.57 R877.2 R740.1
  L03_SIG1 w0.127: v2(183.92,97.91) 184.24,97.59 184.24,97.3 185.18,96.36 186.95,96.36 187.66,95.65 190.22,95.65 192.88,92.98 193.55,92.98 194.67,91.86 201.98,91.86 v2(202.44,92.32)
  L08_SIG2 w0.127: v2(202.44,92.32) 202.9,91.86 202.9,91.24 202.77,91.11 201.55,91.11 201.42,90.99 201.42,90.73 201.55,90.61 202.77,90.61 202.9,90.48 202.9,90.22 202.77,90.1 201.55,90.1 201.42,89.97 201.42,89.72 201.55,89.59 202.77,89.59 202.9,89.46 202.9,89.21 202.77,89.08 201.55,89.08 201.42,88.95 201.42,88.7 201.55,88.57 202.77,88.57 202.9,88.45 202.9,87.88 203.02,87.75 203.45,87.75 203.58,87.62 203.58,87.37 202.9,86.68 202.9,84.33 202.95,84.28 v2(202.95,83.83)
