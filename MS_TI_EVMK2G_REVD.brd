# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EMA_D10: length 42.8
  TOP w0.127: v2(230.9,74.18) 231.23,73.85 RA3.6 ; U17.A7 238.62,59.88 v2(237.48,61.03)
  L08_SIG2 w0.102: 233.65,60.75 233.65,57.39 232.99,56.73 232.99,54.19 233.1,54.09 234.82,54.09 234.92,54.19 234.92,57.55 235.25,57.88 236.65,57.88 236.93,58.16 236.93,60.47 237.21,60.75
  L08_SIG2 w0.127: 233.65,60.75 233.65,64 234.04,64.38 234.04,66.49 233.91,66.62 233.41,66.62 233.29,66.74 233.29,67 233.41,67.12 233.91,67.12 234.04,67.25 234.04,67.51 233.91,67.63 233.41,67.63 233.29,67.76 233.29,68.01 233.41,68.14 233.91,68.14 234.04,68.27 234.04,68.52 233.91,68.65 233.41,68.65 233.29,68.78 233.29,69.03 233.41,69.16 233.91,69.16 234.04,69.28 234.04,69.54 233.91,69.66 233.41,69.66 233.29,69.79 233.29,70.05 233.41,70.17 233.91,70.17 234.04,70.3 234.04,70.55 233.91,70.68 233.41,70.68 233.29,70.81 233.29,71.06 233.41,71.19 233.91,71.19 234.04,71.32 234.04,71.71 231.56,74.18 v2(230.9,74.18) ; 237.21,60.75 237.48,61.01 v2(237.48,61.03)
EMA_D11: length 41.3
  TOP w0.127: RA3.5 231.32,74.5 231.11,74.7 230.45,74.7 229.86,74.11 v2(229.86,73.6) ; U17.D6 v1(237.42,56.45)
  L08_SIG2 w0.127: v2(229.86,73.6) 229.86,72.66 230.15,72.37 230.89,72.37 231.84,71.42 231.84,70.97 231.71,70.84 231.24,70.84 231.11,70.72 231.11,70.46 231.24,70.34 231.71,70.34 231.84,70.21 231.84,69.96 231.71,69.83 231.24,69.83 231.11,69.7 231.11,69.45 231.24,69.32 231.71,69.32 231.84,69.19 231.84,68.94 231.71,68.81 231.24,68.81 231.11,68.69 231.11,68.43 231.24,68.3 231.71,68.3 231.84,68.18 231.84,63.63 231.47,63.26 231.47,56.23 232.23,55.46 232.23,51.27 232.82,50.69 235.11,50.69 235.61,51.19 235.61,55.89 236.16,56.45 v1(237.42,56.45)
EMA_D12: length 42.3
  TOP w0.127: RA1.8 v2(231.04,75.87) ; U17.A6 237.82,59.59 236.7,60.7 236.7,62.3 v2(237.46,63.06)
  L08_SIG2 w0.102: 236.25,60.75 236.25,58.49 236.04,58.28 234.42,58.28 234.16,58.54 234.16,60.75
  L08_SIG2 w0.127: 236.25,60.75 236.25,61.84 v2(237.46,63.06) ; 234.16,60.75 234.16,62.75 234.95,63.54 234.95,64.71 234.59,65.06 234.59,72.85 234.47,72.97 233.71,72.97 233.58,73.1 233.58,73.36 233.71,73.48 234.47,73.48 234.59,73.61 234.59,73.96 234.47,74.08 234.02,74.08 233.89,74.21 233.89,74.46 234.02,74.59 234.47,74.59 234.59,74.72 234.59,75.75 234.47,75.88 233.38,75.88 233.25,76.01 233.25,76.26 233.38,76.39 234.47,76.39 234.59,76.52 234.59,77.18 234.31,77.46 232.27,77.46 231.04,76.23 v2(231.04,75.87)
EMA_D13: length 41.2
  TOP w0.127: RA1.6 230.99,77.03 v2(230.86,77.15) ; v2(237.46,62.04) 236.98,61.56 236.98,60.82 238.2,59.6 238.2,58.03 U17.B6
  L08_SIG2 w0.102: 236.55,60.75 236.55,58.31 236.32,58.08 235.15,58.08 234.72,57.65 234.72,55.03 234.52,54.83 233.5,54.83 233.2,55.13 233.2,56.63 233.91,57.34 233.91,60.75
  L08_SIG2 w0.127: v2(237.46,62.04) 236.55,61.13 236.55,60.75 ; 233.91,60.75 233.91,62.85 234.7,63.64 234.7,64.61 234.34,64.96 234.34,71.74 230.55,75.54 230.55,76.43 230.86,76.74 v2(230.86,77.15)
EMA_D14: length 42.4
  TOP w0.127: RA1.7 v2(230.1,76.52) ; U17.C7 v1(238.22,57.25)
  L08_SIG2 w0.127: v1(238.22,57.25) 237.81,57.66 235.37,57.66 235.15,57.44 235.15,54.02 235.01,53.87 232.96,53.87 232.77,54.07 232.77,56.83 233.4,57.47 233.4,63.97 233.04,64.33 233.04,65.08 232.92,65.21 232.45,65.21 232.32,65.34 232.32,65.59 232.45,65.72 232.92,65.72 233.04,65.85 233.04,66.1 232.92,66.23 232.45,66.23 232.32,66.35 232.32,66.61 232.45,66.74 232.92,66.74 233.04,66.86 233.04,67.12 232.92,67.24 232.45,67.24 232.32,67.37 232.32,67.62 232.45,67.75 232.92,67.75 233.04,67.88 233.04,68.13 232.92,68.26 232.45,68.26 232.32,68.39 232.32,68.64 232.45,68.77 232.92,68.77 233.04,68.89 233.04,69.15 232.92,69.28 232.45,69.28 232.32,69.4 232.32,69.66 232.45,69.78 232.92,69.78 233.04,69.91 233.04,70.16 232.92,70.29 232.45,70.29 232.32,70.42 232.32,70.67 232.45,70.8 232.92,70.8 233.04,70.93 233.04,71.39 230.1,74.34 v2(230.1,76.52)
EMA_D15: length 41.3
  TOP w0.127: U17.E6 v1(237.42,55.65) ; RA1.5 231.65,77.7 v2(231.65,78.35)
  L03_SIG1 w0.102: 232.21,55.26 237.03,55.26 237.42,55.65 v1(237.42,55.65)
  L03_SIG1 w0.127: 232.21,55.26 231.93,55.26 231.65,55.54 231.65,56.97 231.52,57.1 230.5,57.1 230.38,57.23 230.38,57.48 230.5,57.61 231.52,57.61 231.65,57.74 231.65,57.99 231.52,58.12 230.5,58.12 230.38,58.24 230.38,58.5 230.5,58.63 231.52,58.63 231.65,58.75 231.65,59.01 231.52,59.13 230.5,59.13 230.38,59.26 230.38,59.51 230.5,59.64 231.52,59.64 231.65,59.77 231.65,60.02 231.52,60.15 230.5,60.15 230.38,60.28 230.38,60.53 230.5,60.66 231.52,60.66 231.65,60.78 231.65,61.04 231.52,61.17 230.5,61.17 230.38,61.29 230.38,61.55 230.5,61.67 231.52,61.67 231.65,61.8 v2(231.65,78.35)
EMMC_RSTN: length 123.6
  TOP w0.127: U36.1 v2(188.49,197.76) ; R278.1 94.11,175.17 v2(93.75,174.82) 93.34,174.41 91.87,174.41 91.42,173.96 U35.16
  L03_SIG1 w0.127: v2(188.49,197.76) 188.49,198.69 185.21,201.97 177.77,201.97 177.63,201.83 173.95,201.83 166.08,193.97 164.21,192.09 124.05,192.09 123.64,191.68 97.93,191.68 94.11,187.86 94.11,183.77 93.6,183.27 93.6,182.38 94.49,181.5 94.49,179.34 93.75,178.6 v2(93.75,174.82)
EMMC_RSTN_AND: length 2.7
  TOP w0.127: U36.4 183.31,199.66 183.18,199.79 U34.3
EMU_TVD: length 19.5
  TOP w0.127: v2(265.91,75.63) 265.94,75.61 J8.5
  BOTTOM w0.127: R142.1 272.86,78.1 273.46,77.51 273.46,73.67 271.48,71.69 266.57,71.69 265.91,72.35 v2(265.91,75.63)
EMULED1: length 61.7
  TOP w0.127: Q6.1 258.51,29.51 R36.1 v2(258.16,30.97) ; R89.2 244.74,66.76 246.78,68.8 v2(248.54,68.8)
  L03_SIG1 w0.127: v2(258.16,30.97) 258.88,31.69 258.88,50.71 260.83,52.67 260.83,53.71 v2(261.59,54.47)
  L08_SIG2 w0.127: v2(261.59,54.47) 262.38,55.26 262.38,67.99 262.25,68.11 v2(262.25,68.8)
  BOTTOM w0.127: v2(262.25,68.8) v2(248.54,68.8)
EMULED2: length 68.7
  TOP w0.127: Q7.1 254.31,29.56 R37.1 v2(254.01,30.99) ; v2(260.91,69.38) 260.35,68.82 249.73,68.82 249.28,69.28 246.56,69.28 245.97,68.7 244.7,68.7 243.97,67.96 242.77,67.96 242.62,67.81 241.68,67.81 241.05,68.44 v2(240.59,68.44)
  L03_SIG1 w0.127: v2(254.01,30.99) 258.6,35.57 258.6,51.22 260.17,52.8 260.17,54.5 260.19,54.5 261.56,55.87 261.57,55.87 261.44,56 v2(261.59,56.15)
  L08_SIG2 w0.127: v2(261.59,56.15) 261.59,61.97 260.91,62.65 v2(260.91,69.38)
  BOTTOM w0.127: R90.2 240.66,66.86 240.17,67.35 240.17,68.03 v2(240.59,68.44)
EN_3V3_CONN: length 12.3
  TOP w0.127: v2(234.79,236.52) R826.1 235.43,237.45 235.49,237.4 U116.6 ; R909.1 v2(234.44,241.82)
  L08_SIG2 w0.127: v2(234.79,236.52) 236.85,238.59 236.85,240.81 235.84,241.82 v2(234.44,241.82)
  BOTTOM w0.127: v2(234.79,236.52) R826.1
EN_3V3_DCIN: length 10.6
  TOP w0.254: U141.6 282,199.2 R900.1 280.19,198.89 R901.2
  TOP w0.381: v2(279.02,199.28) 279.44,198.86 R901.2 ; v2(279.02,202.71) R907.1 R908.1
  L08_SIG2 w0.381: v2(279.02,199.28) v2(279.02,202.71)
EN_DCDC: length 5.1
  TOP w0.127: R76.2 277.75,92.06 278.99,93.31 278.99,95.24 279.13,95.38 U6.8
EN_LDO1: length 5.2
  TOP w0.127: v2(284.84,100.3) R47.2 284.07,100.2 282.73,98.86 282.49,98.86 281.9,98.28 U6.1
  BOTTOM w0.127: v2(284.84,100.3) R47.2
EN_LDO2: length 5.6
  TOP w0.127: v2(281.85,99.68) 281.85,100.15 282,100.3 R64.1 282.55,99.43 281.4,98.28 U6.2
  BOTTOM w0.127: v2(281.85,99.68) 281.85,100.15 282,100.3 R64.1
ETH1_XI: length 10.4
  TOP w0.127: U92.46 168,49.88 167.46,49.33 167.37,49.33 167.1,49.07 167.1,48.98 166.42,48.3 166.42,47.18 166.04,46.8 166.04,46.27 165.79,46.01 165.24,46.01 C335.2 164.28,46.03 164.08,45.84 164.08,45 163.98,44.9 Y9.2
ETH1_XO: length 9
  TOP w0.127: Y9.1 163.98,48.7 164.12,48.56 164.12,47.99 164.33,47.78 C334.2 165.97,47.78 166.12,47.92 166.12,48.43 166.14,48.45 166.15,48.45 166.82,49.13 166.82,49.18 167.25,49.61 167.31,49.61 168.07,50.38 U92.45
ETH_RSTN: length 290.6
  TOP w0.127: U35.18 90.42,174.29 v2(91.06,174.93) R276.1 ; U89.1 178.93,46.43 v2(178.36,47)
  L03_SIG1 w0.127: v2(78.16,59.7) 79.63,59.7 80.39,58.94 80.39,50.88 80.6,50.67 80.6,50.3 80.39,50.08 80.39,46.46 80.51,46.34 80.51,40.83 80.39,40.72 80.39,39.52 79.45,38.58 79.45,29.66 85.06,24.04 102.08,24.04 104.98,21.15 118.29,21.15 123.27,26.13 126.8,26.13 128.35,27.68 128.35,30.56 133.74,35.96 165.43,35.96 168.05,38.57 174.03,38.57 177.75,42.29 177.75,45.77 177.74,45.78 177.74,46.19 177.75,46.21 177.75,46.4 v2(178.36,47)
  BOTTOM w0.127: v2(91.06,174.93) 91.52,175.39 92.77,175.39 93.04,175.12 93.04,173.78 92.46,173.2 92.46,166.13 67.76,141.44 65.67,141.44 65.04,140.81 65.04,124.98 75.35,114.66 75.35,62.51 v2(78.16,59.7)
ETH_RSTN_AND: length 6.2
  TOP w0.127: R529.2 179.87,41.81 180.01,41.67 180.01,41.29 180.14,41.16 181.41,41.16 181.53,41.29 U88.2 181.53,43.45 181.89,43.81 U89.4
ETHER1_D0N: length 35.4
  TOP w0.102: U92.3 170.97,47.69 170.83,47.55 170.83,36.72 171.55,36 171.55,34.15 171.18,33.78 170.93,33.78 v2(170.5,33.35)
  L03_SIG1 w0.102: v2(170.5,33.35) 170.5,33.73 170.39,33.84 170.1,33.84 169.74,34.2 169.74,34.75 170.23,35.24 171.7,35.24 173,33.95 173,32.37 176.1,29.27 176.1,26.52 175,25.42 175,25.14 J31.10
  BOTTOM w0.102: U94.2 169.21,33.66 169.29,33.75 170.4,33.75 170.5,33.64 v2(170.5,33.35)
ETHER1_D0P: length 35.3
  TOP w0.102: U92.2 170.47,47.73 170.5,47.69 170.5,36.59 171.22,35.87 171.22,35.5 171.12,35.4 170.84,35.4 170.76,35.32 170.76,35.09 170.87,34.99 171.12,34.99 171.22,34.89 171.22,34.29 171.04,34.11 170.86,34.11 v2(170.5,34.47)
  L03_SIG1 w0.102: v2(170.5,34.47) 170.5,34.2 170.41,34.11 170.21,34.11 170.01,34.31 170.01,34.63 170.35,34.98 171.59,34.98 172.73,33.84 172.73,32.26 175.84,29.16 175.84,28.23 175.73,28.13 175.03,28.13 174.93,28.03 174.93,27.82 175.03,27.72 175.73,27.72 175.84,27.62 175.84,26.63 174.93,25.73 174.82,25.73 174.69,25.77 J31.9
  BOTTOM w0.102: U94.1 169.21,34.16 169.29,34.08 170.4,34.08 170.5,34.18 v2(170.5,34.47)
ETHER1_D1N: length 31.1
  TOP w0.102: v2(171.73,32.28) 172.17,32.72 172.57,32.72 172.86,33.01 172.86,36.38 172.35,36.88 172.35,47.65 172.47,47.77 U92.6
  L03_SIG1 w0.102: J31.8 172.38,25.31 172.42,25.45 172.43,25.45 172.96,25.98 172.96,28.88 170.7,31.14 170.7,32.24 171.13,32.67 171.62,32.67 171.73,32.55 v2(171.73,32.28)
  BOTTOM w0.102: v2(171.73,32.28) 171.33,32.69 171.13,32.69 170.66,32.22 169.49,32.22 169.43,32.16 U94.5
ETHER1_D1P: length 31.1
  TOP w0.102: U92.5 171.97,47.7 172.02,47.65 172.02,36.74 172.53,36.24 172.53,33.15 172.44,33.05 172.08,33.05 v2(171.73,33.4)
  L03_SIG1 w0.102: v2(171.73,33.4) 171.73,33.01 171.65,32.93 171.02,32.93 170.43,32.35 170.43,31.03 172.69,28.77 172.69,28.27 172.59,28.17 172.49,28.17 172.39,28.06 172.39,27.86 172.49,27.76 172.59,27.76 172.69,27.66 172.69,26.09 172.38,25.77 172.28,25.73 172.15,25.77 J31.7
  BOTTOM w0.102: v2(171.73,33.4) 171.34,33.02 170.99,33.02 170.53,32.55 169.48,32.55 169.37,32.66 U94.4
ETHER1_D2N: length 39.2
  TOP w0.102: v2(176.46,33.35) 176.92,33.82 177.22,33.82 177.49,34.08 177.49,35.95 173.69,39.75 173.69,46.38 173.35,46.71 173.35,47.65 173.47,47.77 U92.8
  L03_SIG1 w0.102: J31.6 169.84,25.31 169.88,25.45 169.89,25.45 170.45,26.01 170.45,28.42 169.02,29.85 169.02,34.8 170.05,35.83 173.35,35.83 175.37,33.81 176,33.81 v2(176.46,33.35)
  BOTTOM w0.102: v2(176.46,33.35) 176.06,33.75 175.6,33.75 175.52,33.66 U90.2
ETHER1_D2P: length 39.2
  TOP w0.102: U92.7 172.97,47.74 173.02,47.69 173.02,46.58 173.35,46.24 173.35,39.62 177.16,35.81 177.16,35.49 177.09,35.42 176.91,35.42 176.86,35.37 176.86,35.04 176.96,34.94 177.11,34.94 177.16,34.9 177.16,34.22 177.09,34.15 176.66,34.15 176.46,34.35 v2(176.46,34.47)
  L03_SIG1 w0.102: v2(176.46,34.47) 176.06,34.08 175.48,34.08 173.47,36.1 169.94,36.1 168.75,34.91 168.75,29.74 170.18,28.31 170.18,26.12 169.79,25.73 169.74,25.73 169.61,25.77 J31.5
  BOTTOM w0.102: v2(176.46,34.47) 176.06,34.08 175.59,34.08 175.5,34.16 U90.1
ETHER1_D3N: length 49
  TOP w0.102: v2(178.08,31.85) 178.46,32.23 178.81,32.23 179.2,32.62 179.2,36.01 174.88,40.32 174.88,47.67 174.97,47.76 U92.11
  L03_SIG1 w0.102: v2(178.08,31.85) 178.08,32.17 177.98,32.27 177.51,32.27 177.15,32.62 177.15,35.39 175.35,37.19 168.69,37.19 167.91,36.4 167.91,28.17 167.89,28.16 167.89,25.93 167.38,25.42 167.38,25.14 J31.4
  BOTTOM w0.102: v2(178.08,31.85) 177.68,32.25 175.82,32.25 175.73,32.16 U90.5
ETHER1_D3P: length 49.1
  TOP w0.102: U92.10 174.47,47.73 174.55,47.65 174.55,40.19 178.87,35.87 178.87,32.75 178.68,32.56 178.49,32.56 v2(178.08,32.97)
  L03_SIG1 w0.102: v2(178.08,32.97) 178.08,32.73 177.88,32.53 177.62,32.53 177.42,32.73 177.42,35.5 175.46,37.45 168.58,37.45 167.64,36.51 167.64,28.28 167.51,28.15 167.39,28.15 167.28,28.05 167.28,27.85 167.39,27.74 167.51,27.74 167.63,27.62 167.63,26.04 167.31,25.73 167.2,25.73 167.07,25.77 J31.3
  BOTTOM w0.102: U90.4 175.73,32.66 175.82,32.58 177.68,32.58 v2(178.08,32.97)
FB_DCDC: length 17.5
  TOP w0.127: v2(280.4,93.73) U6.9 ; R84.1 272.88,96.74 C29.1 R83.1 v2(272.88,100.43)
  BOTTOM w0.127: v2(280.4,93.73) 279.63,94.5 279.63,95.24 277.6,97.27 273.53,97.27 272.88,97.92 v2(272.88,100.43)
FB_LDO1: length 4.2
  TOP w0.127: U6.11 281.4,93.69 280.43,92.71 R68.1 v2(279.26,92.71)
  BOTTOM w0.127: v2(279.26,92.71) R68.1
FB_LDO2: length 7.2
  TOP w0.127: U6.14 283.37,95.88 283.38,95.87 283.64,95.87 283.87,95.65 283.87,95.65 v2(283.87,95.65) ; v2(284.07,91.94) R44.1
  BOTTOM w0.127: v2(283.87,95.65) 283.87,95.21 284.43,94.65 284.43,92.85 284.07,92.5 v2(284.07,91.94) R44.1
FLASH_HOLD: length 100.6
  TOP w0.127: v2(206.84,177.55) R339.1 206.19,178.48 206.09,178.58 U40.1 ; U1.C18 v1(182.01,115.41)
  L03_SIG1 w0.127: v2(204.44,140.58) 205.03,141.16 205.03,146.83 205.56,147.36 205.56,165.8 207.31,167.55 207.31,177.08 v2(206.84,177.55)
  L08_SIG2 w0.102: v1(182.01,115.41) 182.41,115.41 182.75,115.08 188.67,115.08 189.1,114.65
  L08_SIG2 w0.127: v2(205.54,113.27) 204.83,113.98 197.31,113.98 196.64,114.65 189.1,114.65
  BOTTOM w0.127: v2(205.54,113.27) 205.87,113.27 208.79,116.19 208.79,118.02 210.44,119.67 210.44,124.13 209.89,124.68 209.89,137.09 206.4,140.58 v2(204.44,140.58)
FLASH_RESET#: length 176.1
  TOP w0.127: 61.98,174.56 v2(61.98,175.35) ; U127.1 v2(209.97,184.97)
  L03_SIG1 w0.127: v2(61.98,175.35) 62.44,175.81 62.44,176.83 66.17,180.56 80.81,180.56 81.92,181.66 81.92,184.2 81.55,184.57 81.55,185.39 81.84,185.68 82.41,185.68 82.65,185.43 83.31,185.43 85.34,183.4 85.34,182.13 85.85,181.62 90.3,181.62 91.06,182.39 91.06,184.16 91.82,184.93 91.82,185.18 93.09,186.45 93.09,188.86 97.66,193.44 97.66,194.96 99.31,196.61 110.35,196.61 111.09,195.87 122.2,195.87 122.43,195.65 126.47,195.65 v2(127.51,196.69)
  BOTTOM w0.127: v2(127.51,196.69) 128.65,195.54 150.52,195.54 159.28,186.78 176.33,186.78 176.86,186.25 179.29,186.25 180.05,185.49 206.6,185.49 207.9,184.19 209.19,184.19 v2(209.97,184.97)
FLASH_RSTN_AND: length 4.4
  TOP w0.127: U127.4 205.15,181.16 205.1,181.12 U40.3
FLASH_WPN: length 148.4
  TOP w0.127: U33.17 v2(62.98,175.35) ; v2(192.43,187.47) U40.9 194.41,187.96 194.43,187.98 R344.2
  L03_SIG1 w0.127: v2(169.65,188.56) 169.06,187.97 126.49,187.97 124.71,186.2 119.65,186.2 119.28,185.83 111.26,185.83 108.34,182.91 101.82,182.91 101.57,183.16 94.55,183.16 v2(94.23,182.84)
  L08_SIG2 w0.127: v2(169.65,188.56) 170.26,189.17 177.74,189.17 177.97,188.94 178.13,188.94 179.6,187.47 v2(192.43,187.47)
  BOTTOM w0.127: v2(94.23,182.84) 93.48,182.84 93.43,182.79 93.4,182.79 91.82,181.22 91.82,179.72 89.56,177.46 82.73,177.46 80.94,179.25 76.57,179.25 76.02,178.7 76.02,173.4 75.2,172.57 71.18,172.57 70.69,173.07 65.26,173.07 v2(62.98,175.35)
GATE: length 10.5
  TOP w0.254: v2(279.65,216.8) 279.91,216.8 281.23,218.12 Q20.1
  BOTTOM w0.127: U149.10 280.78,212.12 280.26,212.64 280.26,215.42 279.77,215.91 C827.1 279.67,216.79 v2(279.65,216.8)
GP4-0: length 14.5
  TOP w0.127: U17.E12 v1(243.02,55.65)
  BOTTOM w0.127: R91.2 242.19,64.23 239.75,61.79 239.75,58.03 240.77,57.01 240.77,55.5 241.02,55.25 242.62,55.25 v1(243.02,55.65)
GP4-1: length 2.5
  TOP w0.127: U17.B11 v1(242.22,58.05)
  BOTTOM w0.127: RA13.2 241.53,58.74 v1(242.22,58.05)
GP4-2: length 5.7
  TOP w0.127: U17.E11 v1(242.22,55.65)
  BOTTOM w0.127: RA13.3 241.02,58.74 240.89,58.61 240.89,57.85 241.1,57.65 241.86,57.65 242.22,57.29 v1(242.22,55.65)
GP4-3: length 3.7
  TOP w0.127: U17.C10 v1(241.42,57.25)
  BOTTOM w0.127: RA13.4 240.37,57.86 240.99,57.25 v1(241.42,57.25)
GP4-4: length 1.4
  TOP w0.127: U17.A11 v1(242.22,58.85)
  BOTTOM w0.127: RA13.1 242.22,59.64 v1(242.22,58.85)
GPIO_EXP_INT: length 135.3
  TOP w0.127: v2(94.26,119.04) 93.75,119.04 93.5,118.79 93.5,115.68 93.28,115.47 R11.1 92.74,114.82 92.23,114.32 U51.22 ; U1.A14 184.27,118.21 184.3,118.25 184.66,118.25 184.69,118.21 v1(184.78,118.21)
  L03_SIG1 w0.102: 161.21,108.77 161.79,108.19 163.07,108.19 164.83,109.95 164.83,109.97 165.05,110.2 165.07,110.2 165.11,110.23 166.17,110.23 166.17,110.24 166.22,110.24 166.4,110.41 166.4,110.89 166.52,111.01 168.58,111.01 168.81,111.24 168.81,116.37 169.07,116.63 169.4,116.63 169.59,116.82 169.59,117.94 169.86,118.21 178.13,118.21 178.15,118.19 178.17,118.19 178.39,117.97 178.39,117.71 178.43,117.67 178.43,117.66 178.65,117.43 179.88,117.43 180.06,117.62 180.82,117.62 181.03,117.41 183.31,117.41 184.02,118.13 184.7,118.13 v1(184.78,118.21)
  L03_SIG1 w0.127: v2(94.26,119.04) 102.78,119.04 117.94,103.88 120.27,103.88 129.34,94.81 129.34,93.83 132.55,90.62 132.86,90.62 133.96,89.51 133.96,89.49 134.77,88.67 145.55,88.67 149.45,92.57 149.45,101.01 154.13,105.68 154.13,105.76 154.13,105.99 155.39,107.25 156.66,107.25 158.26,108.85 161.13,108.85 161.21,108.77
HDMI_AC_BIAS_EN: length 86.4
  TOP w0.127: v2(110.19,44.33) 110.19,43.3 107.47,40.59 U102.33 ; U82.F1 v1(134.45,66.52)
  L03_SIG1 w0.127: v2(110.19,44.33) 109.19,45.32 109.19,50.43 110.34,51.58 122.73,51.58 v2(124.13,52.97)
  L08_SIG2 w0.127: v1(134.45,66.52) 134.45,68.18 136.14,69.86 144.78,69.86 145.92,68.72 145.92,68.39 146.05,68.26 147.7,68.26 147.83,68.14 147.83,67.88 147.7,67.76 146.05,67.76 145.92,67.63 145.92,67.38 146.05,67.25 147.7,67.25 147.83,67.12 147.83,66.87 147.7,66.74 146.05,66.74 145.92,66.61 145.92,62.88 132.98,49.94 125.33,49.94 124.06,51.21 123.92,51.21 123.63,51.5 123.63,52.48 v2(124.13,52.97)
HDMI_AUDBCLK: length 234.8
  TOP w0.127: U115.20 289.78,54.69 v2(289.64,54.55) ; TP213.1 101.61,46.62 v2(102.13,46.1) 101.69,46.1 101.12,45.53 101.12,44.62 101.42,44.32 U102.45 ; U69.12 v2(286.58,54.94)
  L03_SIG1 w0.127: v2(286.58,54.94) 287.02,54.94 287.28,54.69 289.5,54.69 v2(289.64,54.55)
  L08_SIG2 w0.127: v2(286.58,54.94) 286.16,54.94 286.1,55.01 283.31,55.01 282.37,54.07 282.37,50.96 279.58,48.17 273.73,48.17 272.44,46.88 269.53,46.88 262.13,39.47 262.13,28.05 260.33,26.25 241.63,26.25 241.4,26.02 233.78,26.02 231.53,28.27 202.59,28.27 199.62,31.24 160.31,31.24 160.3,31.23 160.17,31.23 156.99,28.06 151.92,28.06 151.35,27.49 132.93,27.49 132.25,28.16 132.24,28.16 132.21,28.18 111.95,28.18 111.93,28.2 111.92,28.2 106.26,33.86 106.26,43.69 106.27,43.7 106.27,44.41 105.79,44.9 105.74,44.9 104.53,46.1 v2(102.13,46.1)
HDMI_AUDD0: length 236.1
  TOP w0.127: U102.41 103.42,44.61 v2(102.93,45.1) 102.93,45.54 103.12,45.74 TP208.1 ; v2(286.77,54.24) 286.17,53.64 U69.10 ; U115.18 291.27,55.69 v2(291.13,55.82)
  L03_SIG1 w0.127: v2(291.13,55.82) 291.39,55.56 291.39,54.29 290.63,53.53 288.37,53.53 287.65,54.24 v2(286.77,54.24)
  L08_SIG2 w0.127: v2(102.93,45.1) 103.37,45.54 104.54,45.54 105.56,44.52 105.59,44.52 105.88,44.22 105.88,33.7 111.78,27.8 132.05,27.8 132.75,27.1 151.51,27.1 152.08,27.68 157.15,27.68 160.33,30.85 160.46,30.85 160.47,30.86 199.46,30.86 204.81,25.52 214.35,25.52 215.03,26.2 232.95,26.2 233.51,25.64 241.58,25.64 241.81,25.87 260.49,25.87 263.22,28.6 263.22,39.87 269.85,46.5 272.59,46.5 273.88,47.78 279.73,47.78 282.75,50.8 282.75,53.7 283.59,54.54 286.03,54.54 286.32,54.24 v2(286.77,54.24)
HDMI_AUDD1: length 233.3
  TOP w0.127: U115.16 v2(291.08,56.69) ; TP209.1 103.47,45.58 103.47,45 103.92,44.56 v2(103.92,44.06) U102.40
  L08_SIG2 w0.127: v2(103.92,44.06) 103.92,34.21 111.37,26.76 131.63,26.76 132.25,26.14 152.67,26.14 153.01,26.48 157.48,26.48 160.9,29.9 199.03,29.9 204.38,24.55 214.48,24.55 214.62,24.41 232.28,24.41 232.96,23.74 232.97,23.74 233.07,23.64 248.52,23.64 249.34,24.46 261.68,24.46 264.8,27.58 264.8,40.08 269.91,45.2 272.66,45.2 274.28,46.81 277.84,46.81 279.35,45.3 280.58,45.3 288.87,53.6 288.87,54.59 290.66,56.37 290.76,56.37 v2(291.08,56.69)
HDMI_AUDD2: length 234.1
  TOP w0.127: U115.15 v2(290.2,57.19) ; TP210.1 104.14,45.23 v2(104.01,45.1) 104.42,44.69 U102.39
  L08_SIG2 w0.127: v2(290.2,57.19) 290.2,56.71 287.05,53.56 285.55,53.56 285.05,54.05 283.79,54.05 283.53,53.79 283.53,51.95 283.91,51.56 283.91,49.56 280.93,46.57 278.94,46.57 278.22,47.3 274.08,47.3 272.55,45.77 269.8,45.77 264.06,40.03 264.06,28.76 260.59,25.29 241.94,25.29 241.78,25.14 236.88,25.14 236.14,24.4 233.02,24.4 231.88,25.54 216.92,25.54 216.28,24.91 214.8,24.91 214.68,25.03 204.61,25.03 199.26,30.38 160.67,30.38 157.35,27.07 152.58,27.07 152.13,26.62 132.52,26.62 131.85,27.29 111.61,27.29 104.83,34.07 104.83,44.28 v2(104.01,45.1)
HDMI_AUDD3: length 232.5
  TOP w0.127: U115.14 v2(291.09,57.69) ; U102.37 v2(105.42,44.06) 106.08,44.72 106.81,44.72 TP211.1
  L08_SIG2 w0.127: v2(105.42,44.06) 105.42,33.82 111.69,27.55 131.95,27.55 132.64,26.86 151.82,26.86 152.35,27.4 157.21,27.4 160.41,30.6 160.54,30.6 160.57,30.62 199.36,30.62 204.71,25.28 214.45,25.28 215.03,25.86 231.91,25.86 233.13,24.64 235.99,24.64 236.74,25.39 241.68,25.39 241.91,25.62 260.58,25.62 263.55,28.59 263.55,39.86 269.81,46.12 272.55,46.12 273.98,47.54 278.43,47.54 279.12,46.85 280.56,46.85 280.97,47.27 280.97,48.69 282.99,50.71 282.99,53.6 283.69,54.29 285.57,54.29 286.07,53.8 286.95,53.8 288.16,55.01 288.16,55.78 290.07,57.69 v2(291.09,57.69)
HDMI_AUDFSX: length 236.2
  TOP w0.127: U115.19 290.74,55.19 290.74,55.18 v2(290.09,55.18) ; TP214.1 101.98,44.12 v2(101.92,44.06) U102.44 ; U69.11 284.09,54.29 283.97,54.18 v2(283.97,53.61)
  L03_SIG1 w0.127: v2(283.97,53.61) 283.97,54.22 285.19,55.44 287.73,55.44 287.98,55.19 289.84,55.19 289.85,55.18 v2(290.09,55.18)
  L08_SIG2 w0.127: v2(101.92,44.06) 102.36,44.5 104.1,44.5 104.55,44.06 104.55,33.94 111.44,27.04 131.74,27.04 132.4,26.38 152.45,26.38 152.86,26.79 157.43,26.79 160.78,30.14 199.16,30.14 204.51,24.79 214.58,24.79 214.72,24.65 216.53,24.65 217.18,25.3 231.74,25.3 233.06,23.98 248.46,23.98 249.49,25.01 260.72,25.01 264.34,28.63 264.34,39.97 269.83,45.46 272.58,45.46 274.18,47.06 278.03,47.06 278.89,46.19 281.02,46.19 284.16,49.33 284.16,53.42 v2(283.97,53.61)
HDMI_AUDIO_MSTRCLK: length 10.8
  TOP w0.127: U75.3 285.3,47.68 284.84,48.15 279.91,48.15 279.41,47.65 R537.1 278.38,49.07 R500.2
HDMI_AUDMCLK: length 235.7
  TOP w0.127: U102.38 104.92,44.21 105.23,44.52 105.37,44.52 106.21,45.35 v2(106.43,45.35) 106.43,46.05 106.68,46.31 TP212.1 ; v2(287.02,56.02) 286.59,55.59 U69.13 ; v2(290.3,54.09) 290.3,54.27 290.47,54.09 291.49,54.09 291.59,54.19 U115.21
  L03_SIG1 w0.127: v2(290.3,54.09) 290.7,54.5 290.7,55.39 290.3,55.79 288.52,55.79 288.29,56.02 v2(287.02,56.02)
  L08_SIG2 w0.127: v2(287.02,56.02) 283.77,56.02 281.99,54.24 281.99,51.15 279.4,48.55 272.3,48.55 271.01,47.26 269.37,47.26 269.34,47.22 269.3,47.22 260.99,38.9 260.99,28.95 261.19,28.74 261.19,27.65 260.18,26.64 248.94,26.64 248.94,26.63 241.46,26.63 241.23,26.41 233.94,26.41 231.69,28.65 202.83,28.65 199.09,32.4 176.63,32.4 176.06,31.82 150.02,31.82 149.22,31.03 149.22,28.36 148.73,27.87 133.08,27.87 132.41,28.54 132.4,28.54 132.37,28.56 112.11,28.56 106.76,33.92 106.76,45.02 v2(106.43,45.35)
HDMI_CEC: length 11
  TOP w0.127: U102.71 94.56,34.09 v2(94.06,33.59) ; U108.1 v2(92,27.25)
  L03_SIG1 w0.127: v2(92,27.25) 92.71,27.95 92.71,32.24 v2(94.06,33.59)
HDMI_CEC_D: length 6.1
  TOP w0.127: U102.50 98.92,44.25 98.42,44.74 98.42,45.25 98.76,45.58 TP166.1
HDMI_CLK+: length 34.1
  TOP w0.102: U102.59 95.51,40.09 95.45,40.14 94.7,40.14 94.59,40.04 94.59,39.84 94.49,39.74 94.29,39.74 94.19,39.84 94.19,40.04 94.09,40.14 93.7,40.14 90.27,36.71 90.27,31.5 93.05,28.72 93.05,24.51 92.67,24.13 89.94,24.13 89.5,23.69 89.49,23.69 89.24,23.43 88.43,23.43 86.68,21.68 86.68,21.13 86.8,21 U108.16 86.8,19 86.67,18.87 86.67,18.12 87,17.79 J36.10
HDMI_CLK-: length 34.2
  TOP w0.102: U102.58 95.3,40.59 95.19,40.47 93.57,40.47 89.94,36.84 89.94,31.36 92.72,28.58 92.72,24.64 92.54,24.46 89.81,24.46 89.36,24.02 89.36,24.02 89.1,23.76 88.29,23.76 86.33,21.81 86.33,21.12 86.15,20.94 U108.15 86.15,18.92 86.34,18.73 86.34,18.16 86,17.82 J36.12
HDMI_DATA0: length 87.4
  TOP w0.127: U102.32 v2(107.39,40.09) ; U81.A2 v1(163.85,66.11)
  L03_SIG1 w0.127: v2(107.39,40.09) 109.03,41.72 110.95,41.72 113,43.78 113,46.57 114.35,47.92 v2(115.01,47.92)
  L08_SIG2 w0.127: v2(115.01,47.92) 114.99,47.89 114.99,46.93 120.02,41.9 133.66,41.9 135.53,43.77 135.98,43.77 137.67,45.46 137.67,46.39 139.84,48.56 140.02,48.56 140.61,47.97 140.79,47.97 140.97,48.15 140.97,48.33 140.38,48.92 140.38,49.1 140.56,49.28 140.74,49.28 141.33,48.69 141.51,48.69 141.69,48.87 141.69,49.05 141.1,49.64 141.1,49.82 141.28,50 141.46,50 142.05,49.41 142.23,49.41 142.41,49.59 142.41,49.77 141.82,50.36 141.82,50.54 142.47,51.19 142.47,51.24 143.31,52.08 143.31,52.09 148.51,57.29 162.32,57.29 164.62,59.59 164.62,65.34 v1(163.85,66.11)
HDMI_DATA1: length 87.8
  TOP w0.127: U102.31 107.78,39.59 v2(108.28,40.09) ; U81.A1 v1(163.85,66.91)
  L03_SIG1 w0.127: v2(108.28,40.09) 109.68,41.48 111.32,41.48 113.28,43.45 113.28,46.34 114.33,47.39 115.62,47.39 v2(116.13,47.89)
  L08_SIG2 w0.127: v1(163.85,66.91) 163.45,66.5 163.45,64.89 164.34,64 164.34,59.96 162.05,57.67 147.32,57.67 139.54,49.9 139.54,49.72 140.01,49.25 140.01,49.07 139.83,48.89 139.65,48.89 139.18,49.36 139.01,49.36 138.83,49.18 138.83,49 139.29,48.53 139.29,48.35 139.11,48.17 138.93,48.17 138.47,48.64 138.29,48.64 138.11,48.46 138.11,48.28 138.57,47.82 138.57,47.64 138.39,47.46 138.21,47.46 137.75,47.92 137.57,47.92 137.39,47.74 137.39,45.61 135.83,44.05 135.41,44.05 133.54,42.18 120.22,42.18 116.13,46.27 v2(116.13,47.89)
HDMI_DATA2: length 86
  TOP w0.127: U102.30 v2(107.39,39.09) ; U81.B2 v1(163.05,66.11)
  L03_SIG1 w0.127: v2(113.82,46.07) 113.82,43.42 111.48,41.09 109.98,41.09 108.49,39.59 107.9,39.59 v2(107.39,39.09)
  L08_SIG2 w0.127: v2(113.82,46.07) 115.25,44.63 115.71,44.63 119,41.34 133.93,41.34 135.77,43.18 137.45,43.18 139.95,45.68 140.67,45.68 145.52,50.54 145.52,50.72 145.38,50.86 145.38,51.04 145.56,51.22 145.74,51.22 145.88,51.08 146.06,51.08 151.64,56.66 162.94,56.66 165.2,58.92 165.2,66.89 164.49,67.6 163.16,67.6 162.66,67.11 162.66,67.07 162.66,67.07 162.66,66.74 162.66,66.5 v1(163.05,66.11)
HDMI_DATA3: length 86.2
  TOP w0.127: v2(108.28,39.09) 107.78,38.59 U102.29 ; U81.B1 v1(163.05,66.91)
  L03_SIG1 w0.127: v2(108.28,39.09) 108.46,39.09 110.13,40.76 111.58,40.76 114.5,43.68 v2(114.5,46.45)
  L08_SIG2 w0.127: v1(163.05,66.91) 163.47,67.32 164.21,67.32 164.92,66.61 164.92,59.27 162.69,57.04 150.24,57.04 143.55,50.34 143.55,50.32 143.28,50.05 142.3,49.09 142.3,48.91 142.75,48.46 142.75,48.28 142.57,48.1 142.39,48.1 141.94,48.55 141.76,48.55 141.58,48.38 141.58,48.2 142.03,47.74 142.03,47.56 141.85,47.38 141.67,47.38 141.22,47.84 141.04,47.84 139.41,46.2 138.85,46.2 136.11,43.46 135.65,43.46 133.81,41.62 119.77,41.62 114.95,46.45 v2(114.5,46.45)
HDMI_DATA4: length 86.9
  TOP w0.127: U81.C2 v1(162.25,66.11) ; U102.28 v2(107.39,38.09)
  L03_SIG1 w0.127: v2(107.39,38.09) 107.89,38.58 108.48,38.58 109.84,39.95 109.84,39.97 110.13,40.26 111.54,40.26 117.14,45.86 v2(117.14,47.89)
  L08_SIG2 w0.127: v2(117.14,47.89) 117.14,45.68 120.37,42.46 133.43,42.46 135.29,44.33 135.65,44.33 137.08,45.76 137.08,47.82 138.25,48.99 138.25,49.17 137.73,49.69 137.73,49.87 137.91,50.04 138.09,50.04 138.61,49.53 138.79,49.53 138.97,49.71 138.97,49.88 138.45,50.4 138.45,50.58 138.63,50.76 138.81,50.76 139.33,50.24 139.51,50.24 139.69,50.42 139.69,50.6 139.17,51.12 139.17,51.3 139.35,51.48 139.53,51.48 140.05,50.96 140.23,50.96 147.19,57.93 161.67,57.93 163.45,59.7 163.45,64.02 162.66,64.81 162.66,65.14 162.66,65.47 162.66,65.47 162.66,65.7 v1(162.25,66.11)
HDMI_DATA5: length 87.1
  TOP w0.127: v2(108.28,38.09) 107.78,37.59 U102.27 ; U81.C1 v1(162.25,66.91)
  L08_SIG2 w0.127: v1(162.25,66.91) 162.25,67.26 162.95,67.96 164.63,67.96 165.51,67.09 165.51,57.34 164.57,56.4 151.89,56.4 145.93,50.44 145.93,50.26 146.45,49.74 146.45,49.56 146.27,49.38 146.09,49.38 145.57,49.9 145.39,49.9 145.21,49.72 145.21,49.54 145.73,49.02 145.73,48.84 145.55,48.67 145.37,48.67 144.85,49.18 144.67,49.18 144.49,49 144.49,48.82 145.01,48.31 145.01,48.13 144.83,47.95 144.65,47.95 144.13,48.47 143.95,48.47 138.15,42.66 135.71,42.66 133.91,40.86 127.56,40.86 124.79,38.09 v2(108.28,38.09)
HDMI_DATA6: length 87.4
  TOP w0.127: U81.D2 v1(161.45,66.11) ; v2(108.28,37.09) 107.78,36.59 U102.25
  L03_SIG1 w0.127: v2(108.28,37.09) 110.41,39.21 112.32,39.21 118.54,45.44 v2(118.54,46.5)
  L08_SIG2 w0.127: v1(161.45,66.11) 161.85,65.71 161.85,64.78 162.66,63.97 162.66,63.87 162.66,63.87 162.66,63.54 162.66,63.07 162.66,63.07 162.66,62.74 162.66,62.27 162.66,62.27 162.66,61.94 162.66,59.68 161.16,58.18 145.54,58.18 142.96,55.6 142.96,55.42 143.54,54.83 143.54,54.65 143.36,54.47 143.18,54.47 142.6,55.06 142.42,55.06 142.24,54.88 142.24,54.7 142.82,54.12 142.82,53.94 142.64,53.76 142.46,53.76 141.88,54.34 141.7,54.34 141.52,54.16 141.52,53.98 142.1,53.4 142.1,53.22 141.92,53.04 141.74,53.04 141.16,53.62 140.98,53.62 140.8,53.44 140.8,53.26 141.38,52.68 141.38,52.5 141.2,52.32 141.02,52.32 140.44,52.9 140.26,52.9 135.92,48.55 135.92,46.62 135.15,45.86 135.15,44.67 133.22,42.74 120.75,42.74 118.54,44.95 v2(118.54,46.5)
HDMI_DATA7: length 86.6
  TOP w0.127: U102.24 v2(107.39,36.09) ; U81.D1 v1(161.45,66.91)
  L08_SIG2 w0.127: v1(161.45,66.91) 162.89,68.34 164.65,68.34 165.79,67.2 165.79,57.16 164.77,56.15 153.42,56.15 150.9,53.63 150.72,53.63 150.39,53.96 150.21,53.96 150.03,53.78 150.03,53.6 150.36,53.27 150.36,53.09 150.18,52.91 150,52.91 149.67,53.24 149.49,53.24 149.31,53.06 149.31,52.88 149.64,52.55 149.64,52.37 139.65,42.38 135.83,42.38 133.9,40.45 127.61,40.45 124.59,37.43 119.2,37.43 118.36,36.59 108.49,36.59 108.49,36.59 108.08,36.59 108.07,36.59 107.9,36.59 v2(107.39,36.09)
HDMI_DATA8: length 86.7
  TOP w0.127: U102.23 107.78,35.59 v2(108.28,36.09) ; U81.E2 v1(160.65,66.11)
  L03_SIG1 w0.127: v2(108.28,36.09) 109.1,36.09 111.63,38.62 112.9,38.62 119.38,45.1 v2(120.07,45.1)
  L08_SIG2 w0.127: v2(120.07,45.1) 120.07,44.19 121.06,43.19 131.52,43.19 131.97,43.64 132.15,43.64 132.63,43.16 132.81,43.16 132.99,43.34 132.99,43.52 132.5,44 132.5,44.18 132.68,44.36 132.86,44.36 133.34,43.88 133.52,43.88 133.7,44.06 133.7,44.24 133.22,44.72 133.22,44.9 133.89,45.56 134.07,45.56 134.36,45.27 134.54,45.27 134.72,45.45 134.72,45.63 134.43,45.92 134.43,46.1 134.72,46.4 134.72,48.34 135.72,49.34 135.9,49.34 136.04,49.2 136.22,49.2 136.4,49.38 136.4,49.56 136.26,49.7 136.26,49.88 136.44,50.06 136.62,50.06 136.76,49.92 136.94,49.92 137.12,50.1 137.12,50.28 136.98,50.41 136.98,50.59 137.16,50.77 137.34,50.77 137.48,50.64 137.66,50.64 137.84,50.82 137.84,51 137.7,51.13 137.7,51.31 137.88,51.49 138.06,51.49 138.19,51.35 138.37,51.35 138.55,51.53 138.55,51.71 138.42,51.85 138.42,52.03 138.6,52.21 138.77,52.21 138.91,52.07 139.09,52.07 139.27,52.25 139.27,52.43 139.13,52.57 139.13,52.75 139.31,52.93 139.49,52.93 139.63,52.79 139.81,52.79 139.99,52.97 139.99,53.15 139.85,53.29 139.85,53.47 140.03,53.65 140.21,53.65 140.35,53.51 140.53,53.51 140.71,53.69 140.71,53.87 140.57,54.01 140.57,54.19 140.75,54.37 140.93,54.37 141.07,54.23 141.25,54.23 141.43,54.41 141.43,54.59 141.29,54.73 141.29,54.9 141.47,55.08 141.65,55.08 141.79,54.95 141.97,54.95 142.15,55.13 142.15,55.31 142.01,55.44 142.01,55.62 144.82,58.43 161.04,58.43 162.43,59.83 162.43,61.28 161.85,61.86 161.85,63.98 161.06,64.77 161.06,65.14 161.06,65.47 161.06,65.47 161.06,65.7 v1(160.65,66.11)
HDMI_DATA9: length 87
  TOP w0.127: U102.20 v2(107.39,34.09) ; U81.E1 v1(160.65,66.91)
  L08_SIG2 w0.127: v2(107.39,34.09) 107.89,34.58 116.87,34.58 119.41,37.12 124.99,37.12 127.79,39.92 134.14,39.92 136.19,41.98 139.75,41.98 153.67,55.89 165.02,55.89 166.09,56.96 166.09,67.43 164.92,68.59 162.34,68.59 v1(160.65,66.91)
HDMI_DATA10: length 87.2
  TOP w0.127: U81.F2 v1(159.85,66.11) ; U102.19 107.78,33.59 v2(108.28,34.09)
  L03_SIG1 w0.127: v2(121.59,45.35) 120.62,44.39 119.46,44.39 113.14,38.06 112.01,38.06 109.05,35.11 109.05,34.86 v2(108.28,34.09)
  L08_SIG2 w0.127: v2(121.59,45.35) 121.59,43.91 122.02,43.47 122.28,43.47 122.4,43.6 122.4,45.35 122.53,45.48 122.78,45.48 122.91,45.35 122.91,43.6 123.04,43.47 123.32,43.47 123.45,43.6 123.45,43.88 123.58,44.01 123.83,44.01 123.96,43.88 123.96,43.6 124.09,43.47 124.34,43.47 124.47,43.6 124.47,43.88 124.59,44.01 124.85,44.01 124.98,43.88 124.98,43.6 125.1,43.47 125.36,43.47 125.48,43.6 125.48,43.88 125.61,44.01 125.86,44.01 125.99,43.88 125.99,43.6 126.12,43.47 126.37,43.47 126.5,43.6 126.5,43.88 126.63,44.01 126.88,44.01 127.01,43.88 127.01,43.6 127.13,43.47 127.39,43.47 127.52,43.6 127.52,43.88 127.64,44.01 127.9,44.01 128.02,43.88 128.02,43.6 128.15,43.47 128.4,43.47 128.53,43.6 128.53,43.88 128.66,44.01 128.91,44.01 129.04,43.88 129.04,43.6 129.17,43.47 129.42,43.47 129.55,43.6 129.55,43.88 129.67,44.01 129.93,44.01 130.06,43.88 130.06,43.6 130.18,43.47 131.39,43.47 134.44,46.52 134.44,48.45 144.68,58.69 160.91,58.69 161.92,59.7 161.92,60.97 161.04,61.86 161.04,63.53 161.05,63.54 161.05,63.96 160.25,64.76 160.25,65.71 v1(159.85,66.11)
HDMI_DATA11: length 88.2
  TOP w0.127: U81.F1 v1(159.85,66.91) ; U102.18 v2(105.42,31.61)
  L03_SIG1 w0.127: v2(126.67,47.89) 125.7,47.89 121.26,43.45 119.89,43.45 109.6,33.16 106.97,33.16 v2(105.42,31.61)
  L08_SIG2 w0.127: v2(126.67,47.89) 132.64,47.89 145.97,61.22 146.15,61.22 147.53,59.84 147.71,59.84 147.89,60.02 147.89,60.2 146.51,61.58 146.51,61.76 146.69,61.94 146.87,61.94 148.25,60.56 148.43,60.56 148.61,60.74 148.61,60.92 147.23,62.3 147.23,62.48 147.41,62.66 147.59,62.66 148.97,61.28 149.15,61.28 149.33,61.46 149.33,61.64 147.95,63.02 147.95,63.2 148.12,63.38 148.3,63.38 149.69,62 149.87,62 150.05,62.18 150.05,62.36 148.66,63.74 148.66,63.92 148.87,64.12 157.07,64.12 157.68,64.73 157.68,66.26 157.94,66.51 158.09,66.51 158.89,66.51 159.46,66.51 v1(159.85,66.91)
HDMI_DATA12: length 88
  TOP w0.127: U102.17 104.92,31.22 105.42,30.72 v2(105.87,30.72) ; U81.G2 v1(159.05,66.11)
  L03_SIG1 w0.127: v2(105.87,30.72) 107.8,32.65 110.11,32.65 120.4,42.94 122.22,42.94 v2(123.75,44.46)
  L08_SIG2 w0.127: v2(123.75,44.46) 125.09,44.46 125.22,44.59 125.22,45.99 125.35,46.12 125.6,46.12 125.73,45.99 125.73,44.59 125.86,44.46 126.11,44.46 126.24,44.59 126.24,45.99 126.37,46.12 126.62,46.12 126.75,45.99 126.75,44.59 126.87,44.46 127.13,44.46 127.25,44.59 127.25,45.99 127.38,46.12 127.64,46.12 127.76,45.99 127.76,44.59 127.89,44.46 131.27,44.46 134.16,47.36 134.16,48.57 144.54,58.94 160.53,58.94 161.54,59.96 161.54,60.8 160.78,61.56 160.78,62.88 160.25,63.41 160.25,64.02 159.46,64.81 159.46,65.14 159.46,65.7 v1(159.05,66.11)
HDMI_DATA13: length 86.2
  TOP w0.127: U81.G1 v1(159.05,66.91) ; U102.16 v2(104.42,31.61)
  L03_SIG1 w0.127: v2(126.67,49.16) 126.37,49.16 121.16,43.96 119.63,43.96 109.22,33.54 106.35,33.54 v2(104.42,31.61)
  L08_SIG2 w0.127: v2(126.67,49.16) 127.9,49.16 128.02,49.29 128.02,49.54 128.15,49.67 128.41,49.67 128.53,49.54 128.53,49.29 128.66,49.16 128.91,49.16 129.04,49.29 129.04,49.54 129.17,49.67 129.42,49.67 129.55,49.54 129.55,49.29 129.68,49.16 129.93,49.16 130.06,49.29 130.06,49.54 130.18,49.67 130.44,49.67 130.56,49.54 130.56,49.29 130.69,49.16 130.95,49.16 131.07,49.29 131.07,49.54 131.2,49.67 131.45,49.67 131.58,49.54 131.58,49.29 131.71,49.16 132.84,49.16 147.59,63.91 147.59,64.09 146.37,65.31 146.37,65.49 146.55,65.67 146.73,65.67 147.95,64.45 148.13,64.45 148.51,64.84 148.51,67.09 148.64,67.21 148.89,67.21 149.02,67.09 149.02,66.36 149.15,66.23 150.37,66.23 150.5,66.11 150.5,65.85 150.37,65.72 149.15,65.72 149.02,65.6 149.02,64.84 149.15,64.71 156.74,64.71 157.15,65.12 157.15,66.74 157.73,67.32 158.64,67.32 v1(159.05,66.91)
HDMI_DATA14: length 86.2
  TOP w0.127: U81.H1 v1(158.25,66.91) ; v2(104.42,30.72) 103.92,31.22 U102.15
  L03_SIG1 w0.127: v2(124.13,50.43) 114.53,50.43 111.3,47.21 111.3,43.95 110.39,43.04 107.06,43.04 106.55,42.53 106.55,41.65 103.71,38.81 103.71,35.78 102.5,34.57 102.5,32.23 102.91,31.82 102.91,30.6 102.92,30.59 102.92,30.52 103.21,30.23 103.92,30.23 v2(104.42,30.72)
  L08_SIG2 w0.127: v2(124.13,50.43) 125.91,48.66 128.86,48.66 128.99,48.53 128.99,48.26 129.12,48.14 129.37,48.14 129.5,48.26 129.5,48.53 129.63,48.66 129.88,48.66 130.01,48.53 130.01,48.26 130.13,48.14 130.39,48.14 130.52,48.26 130.52,48.53 130.64,48.66 132.89,48.66 148.62,64.38 156.84,64.38 157.43,64.96 157.43,66.63 157.71,66.91 v1(158.25,66.91)
HDMI_DATA15: length 88.1
  TOP w0.127: U81.H2 v1(158.25,66.11) ; U102.14 v2(103.42,31.61)
  L03_SIG1 w0.127: v2(124.13,49.16) 113.6,49.16 111.58,47.15 111.58,43.84 110.51,42.76 107.21,42.76 106.83,42.38 106.83,41.31 104.17,38.65 104.17,35.36 103.42,34.61 v2(103.42,31.61)
  L08_SIG2 w0.127: v1(158.25,66.11) 158.65,65.71 158.65,64.89 159.45,64.09 159.45,63.5 160.4,62.55 160.4,61.48 161.04,60.85 161.04,59.96 160.26,59.18 147.29,59.18 147.15,59.32 147.15,59.7 147.02,59.83 146.77,59.83 146.64,59.7 146.64,59.32 146.51,59.2 146.26,59.2 146.13,59.32 146.13,59.7 146.01,59.83 145.75,59.83 145.62,59.7 145.62,59.32 145.5,59.2 144.37,59.2 132.54,47.36 125.93,47.36 v2(124.13,49.16)
HDMI_DATA16: length 85.8
  TOP w0.127: U102.13 102.92,31.22 v2(103.42,30.72) ; U82.A2 v1(138.45,65.72)
  L03_SIG1 w0.127: v2(103.42,30.72) 103.91,31.22 103.91,33.31 104.04,33.44 105.12,33.44 105.25,33.56 105.25,33.82 105.12,33.94 104.04,33.94 103.91,34.07 103.91,34.36 104.55,34.99 104.55,38.48 108.55,42.48 110.57,42.48 111.82,43.74 111.82,46.92 113.8,48.9 121.93,48.9 122.51,48.32 124.01,48.32 125.11,49.41 125.11,49.61 124.99,49.72 124.71,49.72 124.59,49.85 124.59,50.1 124.71,50.23 124.99,50.23 125.11,50.35 125.11,50.68 125.12,50.69 125.12,50.81 126.03,51.73 126.03,52.67 126.34,52.97 v2(126.67,52.97)
  L08_SIG2 w0.127: v2(126.67,52.97) 127.6,52.97 127.73,52.85 127.73,52.07 127.86,51.95 128.11,51.95 128.24,52.07 128.24,52.85 128.36,52.97 128.62,52.97 128.74,52.85 128.74,52.07 128.87,51.95 129.13,51.95 129.25,52.07 129.25,52.85 129.38,52.97 129.63,52.97 129.76,52.85 129.76,52.07 129.89,51.95 130.14,51.95 130.27,52.07 130.27,52.85 130.4,52.97 130.65,52.97 130.78,52.85 130.78,52.07 130.9,51.95 131.16,51.95 131.28,52.07 131.28,52.85 131.41,52.97 133.14,52.97 133.62,53.45 133.62,53.52 134.33,54.23 134.53,54.23 139.72,59.43 139.75,59.43 140.83,60.51 140.83,61.94 140.96,62.07 141.35,62.07 141.35,62.58 140.96,62.58 140.83,62.7 140.83,62.96 140.96,63.08 141.35,63.08 141.35,63.59 140.96,63.59 140.83,63.72 140.83,63.97 140.96,64.1 141.35,64.1 141.35,64.61 140.96,64.61 140.55,65.01 140.55,65.19 141.1,65.74 141.1,65.92 140.92,66.1 140.74,66.1 140.19,65.55 140.01,65.55 139.83,65.73 139.83,65.91 140.38,66.46 140.38,66.64 140.2,66.82 140.02,66.82 139.47,66.27 139.29,66.27 138.63,66.94 138.28,66.94 138.05,66.71 138.05,66.3 138.28,66.08 138.28,66.08 138.45,65.9 v1(138.45,65.72)
HDMI_DATA17: length 85.8
  TOP w0.127: U82.A1 v1(138.45,66.52) ; U102.11 101.92,31.22 v2(102.42,30.72)
  L03_SIG1 w0.127: v2(121.59,54.24) 122.33,53.51 122.33,52.82 121.97,52.47 109.09,52.47 107.95,51.32 107.95,45.23 105.51,42.79 105.51,42.18 104.01,40.68 101.37,40.68 100.72,40.03 100.72,32.01 100.91,31.82 100.91,30.53 101.21,30.23 101.92,30.23 v2(102.42,30.72)
  L08_SIG2 w0.127: v2(121.59,54.24) 122.12,54.24 122.73,53.63 124.57,53.63 124.7,53.76 124.7,53.99 124.82,54.12 125.08,54.12 125.2,53.99 125.2,53.76 125.33,53.63 128.44,53.63 128.57,53.76 128.57,54.61 128.7,54.74 128.95,54.74 129.08,54.61 129.08,53.76 129.21,53.63 129.46,53.63 129.59,53.76 129.59,54.61 129.71,54.74 129.97,54.74 130.09,54.61 130.09,53.76 130.22,53.63 130.48,53.63 130.6,53.76 130.6,54.61 130.73,54.74 130.98,54.74 131.11,54.61 131.11,53.76 131.24,53.63 131.49,53.63 131.62,53.76 131.62,54.61 131.75,54.74 132,54.74 132.13,54.61 132.13,53.76 132.25,53.63 132.51,53.63 132.63,53.76 132.63,54.61 132.76,54.74 133.02,54.74 133.14,54.61 133.14,53.89 133.32,53.71 133.47,53.71 134.23,54.47 134.4,54.47 140.55,60.63 140.55,64.42 v1(138.45,66.52)
HDMI_DATA18: length 85.8
  TOP w0.127: U82.B2 v1(137.65,65.72) ; U102.10 v2(101.42,31.61)
  L03_SIG1 w0.127: v2(124.13,54.24) 123.69,54.24 122.63,53.19 122.63,52.52 122.3,52.19 109.4,52.19 108.28,51.07 108.28,45.05 105.79,42.56 105.79,41.92 104.27,40.4 102.74,40.4 101.85,39.51 101.85,35.96 101.09,35.19 101.09,32.4 101.42,32.07 v2(101.42,31.61)
  L08_SIG2 w0.127: v2(124.13,54.24) 124.13,54.72 124,54.84 122.43,54.84 122.3,54.97 122.3,55.22 122.43,55.35 124,55.35 124.13,55.48 124.13,56.15 124.38,56.4 124.97,56.4 125.1,56.28 125.1,54.52 125.23,54.39 125.48,54.39 125.61,54.52 125.61,55.14 125.74,55.26 126.6,55.26 126.72,55.39 126.72,55.64 126.6,55.77 125.74,55.77 125.61,55.9 125.61,56.28 125.74,56.4 126.81,56.4 126.93,56.53 126.93,56.92 127.06,57.05 127.32,57.05 127.44,56.92 127.44,56.53 127.57,56.4 127.82,56.4 127.95,56.53 127.95,56.92 128.08,57.05 128.33,57.05 128.46,56.92 128.46,56.53 128.59,56.4 128.84,56.4 128.97,56.53 128.97,56.92 129.09,57.05 129.35,57.05 129.47,56.92 129.47,56.53 129.6,56.4 129.86,56.4 129.98,56.53 129.98,56.92 130.11,57.05 130.36,57.05 130.49,56.92 130.49,56.53 130.62,56.4 130.87,56.4 131,56.53 131,56.92 131.13,57.05 131.38,57.05 131.51,56.92 131.51,56.53 131.63,56.4 131.89,56.4 132.01,56.53 132.01,56.92 132.14,57.05 132.4,57.05 132.52,56.92 132.52,56.53 132.65,56.4 132.9,56.4 133.03,56.53 133.03,56.92 133.16,57.05 133.41,57.05 133.54,56.92 133.54,56.53 133.67,56.4 133.92,56.4 134.05,56.53 134.05,56.92 134.17,57.05 134.43,57.05 134.55,56.92 134.55,56.53 134.68,56.4 135.54,56.4 139.99,60.86 139.99,63.56 139.07,64.48 138.28,64.48 138.06,64.7 138.06,65.15 137.65,65.56 v1(137.65,65.72)
HDMI_DATA19: length 86.2
  TOP w0.127: U82.B1 v1(137.65,66.52) ; U102.9 100.92,31.22 v2(101.42,30.72)
  L03_SIG1 w0.127: v2(126.67,54.24) 126.16,53.74 125.35,53.74 125.22,53.86 125.22,55.39 125.09,55.51 124.84,55.51 124.71,55.39 124.71,53.86 124.59,53.74 123.9,53.74 123.01,52.85 123.01,52.47 122.43,51.88 110.03,51.88 108.66,50.51 108.66,45.05 106.17,42.56 106.17,41.67 104.52,40.02 102.87,40.02 102.83,39.98 102.74,39.98 102.13,39.37 102.13,35.84 101.42,35.13 101.42,32.47 101.91,31.97 101.91,31.22 v2(101.42,30.72)
  L08_SIG2 w0.127: v1(137.65,66.52) 137.67,66.5 137.67,66.3 138.05,65.92 138.05,65.55 138.28,65.31 138.65,65.31 140.27,63.69 140.27,60.74 134.51,54.98 133.5,54.98 133.38,55.11 133.38,56.03 133.25,56.16 133,56.16 132.87,56.03 132.87,55.11 132.74,54.98 132.49,54.98 132.36,55.11 132.36,56.03 132.23,56.16 131.98,56.16 131.85,56.03 131.85,55.11 131.73,54.98 131.47,54.98 131.35,55.11 131.35,56.03 131.22,56.16 130.96,56.16 130.84,56.03 130.84,55.11 130.71,54.98 130.46,54.98 130.33,55.11 130.33,56.03 130.2,56.16 129.95,56.16 129.82,56.03 129.82,55.11 129.69,54.98 129.44,54.98 129.31,55.11 129.31,56.03 129.19,56.16 128.93,56.16 128.81,56.03 128.81,55.11 128.68,54.98 128.42,54.98 128.3,55.11 128.3,56.03 128.17,56.16 127.92,56.16 127.79,56.03 127.79,55.11 127.66,54.98 126.91,54.98 126.67,54.74 v2(126.67,54.24)
HDMI_DATA20: length 86.6
  TOP w0.127: U82.C2 v1(136.85,65.72) ; U102.8 v2(100.42,31.61)
  L03_SIG1 w0.127: v2(100.42,31.61) 100.42,40.12 101.46,41.16 103.63,41.16 104.92,42.45 104.92,42.71 107.54,45.33 107.54,51.63 108.89,52.97 v2(119.05,52.97)
  L08_SIG2 w0.127: v2(119.05,52.97) 118.87,52.8 118.87,50.31 119.13,50.05 119.89,50.05 120.33,50.5 120.33,55.32 120.51,55.5 120.51,55.68 120.37,55.83 120.37,56.01 120.55,56.19 120.73,56.19 120.87,56.04 121.05,56.04 121.23,56.22 121.23,56.4 121.09,56.55 121.09,56.73 121.27,56.91 121.44,56.91 121.59,56.76 121.77,56.76 121.95,56.94 121.95,57.12 121.8,57.26 121.8,57.44 121.98,57.62 122.16,57.62 122.31,57.48 122.49,57.48 123.06,58.05 123.56,58.05 123.69,58.18 123.69,58.45 123.81,58.57 124.07,58.57 124.2,58.45 124.2,58.18 124.32,58.05 124.58,58.05 124.7,58.18 124.7,58.45 124.83,58.57 125.08,58.57 125.21,58.45 125.21,58.18 125.34,58.05 125.59,58.05 125.72,58.18 125.72,58.45 125.85,58.57 126.1,58.57 126.23,58.45 126.23,58.18 126.35,58.05 126.61,58.05 126.74,58.18 126.74,58.45 126.86,58.57 127.12,58.57 127.24,58.45 127.24,58.18 127.37,58.05 127.62,58.05 127.75,58.18 127.75,58.45 127.88,58.57 128.13,58.57 128.26,58.45 128.26,58.18 128.39,58.05 128.64,58.05 128.77,58.18 128.77,58.45 128.89,58.57 129.15,58.57 129.28,58.45 129.28,58.18 129.4,58.05 129.66,58.05 129.78,58.18 129.78,58.45 129.91,58.57 130.16,58.57 130.29,58.45 130.29,58.18 130.42,58.05 130.67,58.05 130.8,58.18 130.8,58.45 130.93,58.57 131.18,58.57 131.31,58.45 131.31,58.18 131.43,58.05 131.69,58.05 131.82,58.18 131.82,58.45 131.94,58.57 132.2,58.57 132.32,58.45 132.32,58.18 132.45,58.05 132.7,58.05 132.83,58.18 132.83,58.45 132.96,58.57 133.21,58.57 133.34,58.45 133.34,58.18 133.47,58.05 133.72,58.05 133.85,58.18 133.85,58.45 133.97,58.57 134.23,58.57 134.36,58.45 134.36,58.18 134.48,58.05 134.74,58.05 134.86,58.18 134.86,58.45 134.99,58.57 135.24,58.57 135.37,58.45 135.37,58.18 135.5,58.05 136.4,58.05 139.43,61.09 139.43,63.33 138.79,63.97 137.21,63.97 136.45,64.73 136.45,65.31 v1(136.85,65.72)
HDMI_DATA21: length 86
  TOP w0.127: U82.C1 v1(136.85,66.52) ; U102.7 99.92,31.22 v2(100.42,30.72)
  L03_SIG1 w0.127: v2(121.59,52.97) 121.06,53.51 117.98,53.51 117.75,53.28 108.43,53.28 107.16,52.01 107.16,46.98 105.92,45.73 105.92,45.35 103.38,42.81 102.34,42.81 99.51,39.98 99.44,39.98 99.01,39.55 99.01,35 99.91,34.1 99.91,31.23 v2(100.42,30.72)
  L08_SIG2 w0.127: v2(121.59,52.97) 121.03,53.53 121.03,54.55 121.45,54.96 121.45,55.14 121.14,55.45 121.14,55.63 121.32,55.8 121.5,55.8 121.8,55.5 121.98,55.5 122.16,55.68 122.16,55.86 121.86,56.16 121.86,56.34 122.04,56.52 122.22,56.52 122.52,56.22 122.7,56.22 122.88,56.4 122.88,56.58 122.58,56.88 122.58,57.06 122.76,57.24 122.94,57.24 123.24,56.94 123.42,56.94 123.77,57.29 124.35,57.29 124.48,57.42 124.48,57.69 124.61,57.81 124.86,57.81 124.99,57.69 124.99,57.42 125.12,57.29 125.37,57.29 125.5,57.42 125.5,57.69 125.62,57.81 125.88,57.81 126,57.69 126,57.42 126.13,57.29 126.39,57.29 126.51,57.42 126.51,57.69 126.64,57.81 126.89,57.81 127.02,57.69 127.02,57.42 127.15,57.29 127.4,57.29 127.53,57.42 127.53,57.69 127.66,57.81 127.91,57.81 128.04,57.69 128.04,57.42 128.16,57.29 128.42,57.29 128.54,57.42 128.54,57.69 128.67,57.81 128.93,57.81 129.05,57.69 129.05,57.42 129.18,57.29 129.43,57.29 129.56,57.42 129.56,57.69 129.69,57.81 129.94,57.81 130.07,57.69 130.07,57.42 130.2,57.29 130.45,57.29 130.58,57.42 130.58,57.69 130.7,57.81 130.96,57.81 131.08,57.69 131.08,57.42 131.21,57.29 131.47,57.29 131.59,57.42 131.59,57.69 131.72,57.81 131.97,57.81 132.1,57.69 132.1,57.42 132.23,57.29 132.48,57.29 132.61,57.42 132.61,57.69 132.74,57.81 132.99,57.81 133.12,57.69 133.12,57.42 133.24,57.29 133.5,57.29 133.62,57.42 133.62,57.69 133.75,57.81 134.01,57.81 134.13,57.69 134.13,57.42 134.26,57.29 134.51,57.29 134.64,57.42 134.64,57.69 134.77,57.81 135.02,57.81 135.15,57.69 135.15,57.42 135.28,57.29 136.03,57.29 139.71,60.97 139.71,63.44 138.95,64.2 137.78,64.2 137.24,64.74 137.25,64.75 137.25,66.12 v1(136.85,66.52)
HDMI_DATA22: length 86.9
  TOP w0.127: U102.6 v2(99.42,31.61) ; U82.D2 v1(136.05,65.72)
  L03_SIG1 w0.127: v2(99.42,31.61) 99.42,34.2 98.7,34.92 98.7,39.8 101.37,42.47 101.37,42.47 102.1,43.19 102.79,43.19 103.42,43.82 103.42,45.78 106.78,49.14 106.78,52.19 108.46,53.86 108.77,53.86 108.9,53.99 108.9,54.96 109.03,55.08 109.28,55.08 109.41,54.96 109.41,53.99 109.53,53.86 109.79,53.86 109.92,53.99 109.92,54.96 110.04,55.08 110.3,55.08 110.42,54.96 110.42,53.99 110.55,53.86 110.8,53.86 110.93,53.99 110.93,54.96 111.06,55.08 111.31,55.08 111.44,54.96 111.44,53.99 111.57,53.86 115.29,53.86 115.82,54.4 v2(116.99,54.4)
  L08_SIG2 w0.127: v1(136.05,65.72) 136.02,65.68 136.02,65.44 135.89,65.31 135.89,65.31 135.66,65.08 135.65,65.07 135.65,64.75 135.64,64.74 136.64,63.74 138.62,63.74 139.15,63.21 139.15,61.2 136.77,58.82 124.61,58.82 124.49,58.94 124.49,59.08 124.36,59.21 124.1,59.21 123.98,59.08 123.98,58.94 123.85,58.82 123.6,58.82 123.47,58.94 123.47,59.08 123.34,59.21 123.09,59.21 122.96,59.08 122.96,58.94 122.47,58.45 122.29,58.45 121.99,58.75 121.81,58.75 121.63,58.57 121.63,58.39 121.93,58.09 121.93,57.91 121.75,57.73 121.57,57.73 121.27,58.03 121.09,58.03 120.91,57.85 120.91,57.67 121.21,57.37 121.21,57.19 121.03,57.01 120.85,57.01 120.55,57.32 120.37,57.32 120.19,57.14 120.19,56.96 120.49,56.65 120.49,56.47 120.31,56.29 120.13,56.29 119.83,56.6 119.65,56.6 119.47,56.42 119.47,56.24 119.77,55.93 119.77,54.13 119.25,53.61 118.25,53.61 118.12,53.48 118.12,51.83 118,51.7 117.74,51.7 117.61,51.83 117.61,53.48 117.49,53.61 117.23,53.61 116.99,53.85 v2(116.99,54.4)
HDMI_DATA23: length 86.9
  TOP w0.127: U102.4 v2(98.42,31.61) ; U82.D1 v1(136.05,66.52)
  L03_SIG1 w0.127: v2(98.42,31.61) 98.42,39.91 101.22,42.71 101.27,42.71 102.41,43.85 102.41,43.93 102.42,43.93 102.42,45.34 106.48,49.39 106.48,53.56 108.51,55.59 117.7,55.59 v2(119.05,54.24)
  L08_SIG2 w0.127: v2(119.05,54.24) 119.05,56.45 119.91,57.32 119.91,57.5 118.12,59.28 118.12,59.46 118.3,59.64 118.48,59.64 120.27,57.85 120.45,57.85 120.63,58.03 120.63,58.21 118.84,60 118.84,60.18 119.02,60.36 119.2,60.36 120.06,59.51 120.24,59.51 120.58,59.85 120.76,59.85 120.94,59.67 120.94,59.49 120.59,59.15 120.59,58.97 120.99,58.57 121.17,58.57 122.05,59.45 124.68,59.45 125.07,59.06 136.61,59.06 138.87,61.32 138.87,62.66 138.62,62.91 135.09,62.91 135.08,62.9 134.86,63.12 134.86,65.08 135.1,65.32 135.49,65.32 135.66,65.5 135.66,65.88 135.89,66.11 135.95,66.11 136.05,66.22 v1(136.05,66.52)
HDMI_EXTSWING: length 3.5
  TOP w0.127: v2(94.95,42.09) 94.95,41.77 95.13,41.59 U102.56
  BOTTOM w0.127: v2(94.95,42.09) 94.95,41.52 95.2,41.26 R765.1
HDMI_HPLG: length 25.3
  TOP w0.127: U108.4 90.05,29.06 89,30.11 89,37.2 92.84,41.04 92.84,42.56 94.08,43.8 v2(96.22,43.8) 96.6,43.8 96.92,43.48 U102.54
  BOTTOM w0.127: v2(96.22,43.8) 96.22,42.8 R764.1
HDMI_HSYNC: length 86.6
  TOP w0.127: U82.E1 v1(135.25,66.52) ; U102.34 107.47,41.09 109.55,43.17 v2(109.55,43.93)
  L03_SIG1 w0.127: v2(109.55,43.93) 109.86,43.62 110.18,43.62 110.72,44.16 110.72,48.45 113.36,51.09 123.52,51.09 v2(124.13,51.7)
  L08_SIG2 w0.127: v1(135.25,66.52) 135.25,66.71 136.89,68.34 137.14,68.34 137.27,68.21 137.27,67.56 137.4,67.43 137.65,67.43 137.78,67.56 137.78,68.21 137.91,68.34 138.16,68.34 138.29,68.21 138.29,67.56 138.41,67.43 138.67,67.43 138.8,67.56 138.8,68.21 138.92,68.34 139.18,68.34 139.3,68.21 139.3,67.56 139.43,67.43 139.68,67.43 139.81,67.56 139.81,68.21 139.94,68.34 140.19,68.34 140.32,68.21 140.32,67.56 140.45,67.43 140.7,67.43 140.83,67.56 140.83,68.21 140.95,68.34 141.21,68.34 141.34,68.21 141.34,67.56 141.46,67.43 141.72,67.43 141.84,67.56 141.84,68.21 141.97,68.34 142.22,68.34 142.35,68.21 142.35,67.56 142.48,67.43 142.73,67.43 142.86,67.56 142.86,68.21 142.99,68.34 143.51,68.34 144.4,67.45 144.4,66.34 144.27,66.21 142.62,66.21 142.49,66.08 142.49,65.83 142.62,65.7 144.27,65.7 144.4,65.57 144.4,65.32 144.27,65.19 142.62,65.19 142.49,65.07 142.49,64.81 142.62,64.69 144.27,64.69 144.4,64.56 144.4,64.3 144.27,64.18 142.62,64.18 142.49,64.05 142.49,63.8 142.62,63.67 144.27,63.67 144.4,63.54 144.4,63.03 140.26,58.89 134.84,53.47 134.65,53.47 134.38,53.2 134.38,53.12 134.34,53.08 134.34,52.34 133.07,51.07 125.25,51.07 124.61,51.7 v2(124.13,51.7)
