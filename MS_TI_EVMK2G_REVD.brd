# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BMC_BOOTMODE15: length 191
  TOP w0.127: v2(165.99,84.09) 166.48,84.58 166.48,86.93 166.41,87 U67.26 ; U20.P3 v2(71.43,194.66)
  L08_SIG2 w0.102: v2(71.43,194.66) 72.05,195.28 72.82,195.28 73.04,195.5 73.04,195.91 73.25,196.13 75.22,196.13 75.45,196.36 77.77,196.36 77.77,196.36 78.89,196.36 79.58,195.67 79.58,195.65 79.71,195.52 79.71,192.51 79.36,192.17 79.36,191.44 78.87,190.95 78.85,190.95 78.61,190.71 78.61,190.69 78.08,190.16
  L08_SIG2 w0.127: v2(165.99,84.09) 165.35,84.09 163.75,85.69 155.42,85.69 154.76,86.35 135.15,86.35 133.38,88.13 115.39,88.13 112.34,91.17 112.34,91.84 107.25,96.93 107.25,131.13 77.27,161.11 77.27,188.25 77.85,188.84 77.85,189.93 78.08,190.16
BMC_BOOTSELECT: length 12.4
  TOP w0.102: U20.V2 70.65,192.51 70.24,192.51 69.05,191.32 68.95,191.32
  TOP w0.127: J10.1 62.1,188.23 R225.1 64.37,188.78 64.14,189.01 64.14,189.88 64.26,190.01 66.9,190.01 68.21,191.32 68.95,191.32
BMC_CDCM_RST: length 37.9
  TOP w0.127: U20.E7 73.29,198.59 72.98,198.59 72.97,198.59 v1(72.97,198.59) ; U33.4 v2(60.98,170.25)
  L08_SIG2 w0.102: 69.56,197.73 69.99,198.16 71.58,198.16 72.16,197.58 73.1,197.58 73.3,197.78 73.3,198.25 v1(72.97,198.59)
  L08_SIG2 w0.127: 69.56,197.73 69.55,197.73 67.28,195.46 67.28,195.18 67.28,194.89 67.1,194.71 67.1,194.7 67.07,194.67 67.07,184.81 66.22,183.95 66.22,175.19 62.58,171.55 62.29,171.55 v2(60.98,170.25)
BMC_CLK_PDN: length 46.7
  TOP w0.127: U31.4 v2(46.11,176.87) ; v1(74.42,192.7) 74.42,192.74 U20.T8
  L03_SIG1 w0.127: v1(74.42,192.7) 74.42,192.04 71.91,189.52 68.35,189.52 67.44,188.61 67.44,187.9 59.44,179.9 59.44,178.07 58.33,176.96 54.75,176.96 52.98,178.73 50.98,178.73 49.86,177.61 49.86,177.21 46.51,173.85 46.49,173.87 46.34,173.71 45.88,173.71 45.55,174.04 45.55,174.36 44.77,175.14 44.77,176.45 45.19,176.87 v2(46.11,176.87)
BMC_CLK_REF_SEL: length 40.2
  TOP w0.127: v1(77.44,198.39) 77.6,198.23 U20.F16 ; U33.8 v2(62.98,170.25)
  L08_SIG2 w0.102: 69.89,197.31 71.69,197.31 71.76,197.37 73.2,197.37 73.94,198.11 74.32,198.11 74.35,198.13 74.65,198.13 74.68,198.11 75.84,198.11 76.07,198.34 77.39,198.34 v1(77.44,198.39)
  L08_SIG2 w0.127: 69.89,197.31 69.51,197.31 67.6,195.4 67.6,194.76 67.42,194.58 67.42,174.6 65.94,173.12 65.85,173.12 64.32,171.59 63.5,171.59 62.98,171.07 v2(62.98,170.25)
BMC_CLK_SYNC: length 39.7
  TOP w0.127: U31.5 v2(45.33,176.22) ; U20.U8 v1(73.45,192.73)
  L03_SIG1 w0.127: v2(45.33,176.22) 45.33,175.56 45.88,175.01 46.7,175.01 54.48,182.79 54.48,184.13 55.15,184.8 62.14,184.8 68.12,190.78 71.5,190.78 v1(73.45,192.73)
BMC_CP2105_RXD: length 161.3
  TOP w0.127: U74.21 v2(20.19,63.89) ; U129.4 32.95,206.69 34.06,205.58 v2(34.62,205.58)
  L03_SIG1 w0.127: v2(20.19,63.89) 20.19,65.16 21.6,66.58 21.6,85.29 26.92,90.61 26.92,99.37 24.51,101.78 24.51,130.98 25.76,132.22 33.66,132.22 36.55,135.12 36.55,189.11 32.5,193.16 32.5,203.46 v2(34.62,205.58)
BMC_CP2105_TXD: length 164.8
  TOP w0.127: U129.5 33.35,206.8 33.78,206.36 v2(34.9,206.36) ; U74.20 20.69,63.88 v2(21.08,64.28)
  L03_SIG1 w0.127: v2(21.08,64.28) 21.08,65.63 21.84,66.4 21.84,85.19 27.18,90.52 27.18,99.46 24.75,101.88 24.75,130.76 25.83,131.84 33.78,131.84 36.91,134.97 36.91,189.09 32.74,193.26 32.74,200.85 33.66,201.77 36.17,201.77 36.9,202.5 36.9,204.36 v2(34.9,206.36)
BMC_EEPROM_WP: length 45.6
  TOP w0.127: 61.98,171.16 v2(61.98,170.25) ; U20.E17 v1(78.43,199.21)
  L08_SIG2 w0.102: v1(78.43,199.21) 78.43,198.66 77.27,197.5 76.91,197.5 76.66,197.75 76.66,197.77 76.47,197.96 76.04,197.96 75.82,197.73 75.82,197.6 75.45,197.23
  L08_SIG2 w0.127: 75.45,197.23 75.32,197.09 73.74,197.09 73.69,197.14 71.86,197.14 71.63,196.92 69.52,196.92 67.92,195.31 67.92,194.62 67.74,194.45 67.74,173.3 67.49,173.04 67.49,173.03 65.2,170.74 63.83,170.74 63.48,170.39 63.48,169.21 63.17,168.9 62.79,168.9 62.48,169.21 62.48,169.74 v2(61.98,170.25)
BMC_EMMC_RSTN: length 42
  TOP w0.102: 80.9,194.3 80.19,195.01 79.21,195.01 U20.N18
  TOP w0.127: R204.1 v2(86.78,193.18) 86.64,193.04 86.64,192.27 86.24,191.88 85.87,191.88 85.5,192.25 85.5,192.66 85.03,193.13 82.07,193.13 80.9,194.3 ; U35.8 v2(90.92,168.34)
  L08_SIG2 w0.127: v2(90.92,168.34) 90.92,168.66 88.79,170.79 86.41,170.79 84.72,172.48 84.72,184.59 84.72,190.38 86.21,191.86 86.23,191.86 86.54,192.17 86.54,192.19 86.78,192.43 v2(86.78,193.18)
BMC_ETH_RSTN: length 44.7
  TOP w0.102: U20.K18 79.21,196.51 79.55,196.51 79.72,196.33 79.73,196.33 79.95,196.12 80.9,196.12
  TOP w0.127: R199.1 86.82,196.15 v2(86.66,195.99) 86.34,195.67 85.7,195.67 85.12,196.26 81.94,196.26 81.66,195.98 81.08,195.98 80.94,196.12 80.9,196.12 ; 89.92,169.26 v2(89.92,168.34)
  L08_SIG2 w0.127: v2(89.92,168.34) 88.87,169.39 86.31,169.39 84.16,171.54 84.16,184.36 84.16,192.76 84.45,193.05 85.6,193.05 86.39,193.84 86.87,193.84 87.3,194.27 87.3,195.34 v2(86.66,195.99)
BMC_FLASH_RESET#: length 80.9
  TOP w0.102: 80.9,198.92 80.9,198.76 80.36,198.23 U20.F18
  TOP w0.127: v2(83.19,199.77) 82.69,200.27 82.24,200.27 80.9,198.92 ; v2(60.98,169.36) 61.48,169.86 U33.5
  L03_SIG1 w0.127: v2(84.53,207.25) 84.23,206.95 83.01,206.95 82.46,206.4 79.67,206.4 79.35,206.09 77.14,206.09 76.15,207.08 68.61,207.08 68.05,206.52 61.01,206.52 v2(57.84,203.34)
  L08_SIG2 w0.127: v2(84.53,207.25) 84.91,207.25 85.12,207.05 v2(85.12,202.68)
  BOTTOM w0.127: v2(83.19,199.77) 83.19,200.75 v2(85.12,202.68) ; v2(57.84,203.34) 57.84,183.75 57.83,183.75 57.83,183.37 57.84,183.36 57.84,183.05 60.5,180.38 60.5,175.4 60.12,175.02 60.12,171.62 60.52,171.22 60.52,169.82 v2(60.98,169.36)
BMC_FLASH_WPN: length 44.6
  TOP w0.127: U20.H17 78.43,196.78 v1(78.44,196.76) ; v2(61.98,169.36) 62.48,169.86 U33.7
  L08_SIG2 w0.102: v1(78.44,196.76) 78.43,196.76 78.22,196.98 78.22,197 77.92,197.3 76.86,197.3 76.72,197.16 75.98,197.16 75.49,196.66 73.96,196.66 73.63,196.33 69.4,196.33 68.83,195.77
  L08_SIG2 w0.127: v2(61.98,169.36) 61.98,169.32 62.67,168.62 64.06,168.62 68.41,172.98 68.41,191.02 68.81,191.42 68.81,193.44 68.68,193.56 68.68,195.62 68.83,195.77
BMC_GPIO0: length 465.1
  L08_SIG2 w0.127: JP1.89 298.78,33.12 298.5,33.12 292.92,38.7 286.46,38.7 282.89,42.27 279.62,42.27 278.57,43.31 269.05,43.31 265.58,39.85 265.58,26.29 262,22.71 224.25,22.71 223.46,23.5 210.77,23.5 210.36,23.09 202.2,23.09 200.43,24.86 199.95,24.86 195.71,29.1 161.32,29.1 157.91,25.68 153.91,25.68 153.54,25.31 131.89,25.31 131.31,25.9 110.79,25.9 109.09,27.6 96.48,27.6 86.74,37.34 86.74,59.91 v2(87.17,60.34)
  BOTTOM w0.127: v2(87.17,60.34) 86.16,61.36 79.12,61.36 76.67,63.81 76.67,115.05 75.27,116.45 75.27,146.2 89.41,160.34 89.88,160.81 91.89,162.82 93.21,164.14 95.96,166.89 95.96,203 95.44,203.52 82.25,216.71 76.23,216.71 75.08,215.56 75.08,208.17 76.61,206.64 R164.2
BMC_GPIO1: length 471.7
  TOP w0.127: v2(70.99,206.1) 70.92,206.02 R162.2
  L08_SIG2 w0.127: JP1.88 301.45,33.4 298.62,33.4 293.04,38.98 286.66,38.98 282.32,43.32 279.2,43.32 278.97,43.55 268.95,43.55 265.34,39.95 265.34,26.44 261.85,22.95 224.35,22.95 223.56,23.74 210.67,23.74 210.26,23.33 203.17,23.33 200.51,26 199.58,26 196.2,29.38 161.19,29.38 157.73,25.92 153.72,25.92 153.39,25.59 132.01,25.59 131.42,26.18 110.92,26.18 109.12,27.98 99.59,27.98 96.24,31.33 94.53,31.33 89.74,36.13 89.74,59.77 85.23,64.28 v2(80.9,64.28)
  BOTTOM w0.127: v2(70.99,206.1) 70.99,207.15 73.1,209.26 73.1,216.16 75,218.06 75.27,218.33 81.82,218.33 95.79,204.35 95.79,204.35 96.8,203.35 96.8,166.54 94.21,163.95 92.89,162.63 90.88,160.63 76,145.74 76,116.75 77.39,115.35 77.39,64.73 78.17,63.96 80.58,63.96 v2(80.9,64.28)
BMC_GPIO3: length 475.1
  L08_SIG2 w0.102: 269.88,44.82 270.03,44.97 272.77,44.97 273.34,45.54 273.35,45.54 273.59,45.79
  L08_SIG2 w0.127: JP1.87 295.18,39.26 286.89,39.26 281.13,45.02 279.25,45.02 277.7,46.57 274.38,46.57 273.59,45.79 ; 269.88,44.82 265.1,40.05 265.1,26.6 261.7,23.19 224.45,23.19 223.66,23.98 210.53,23.98 210.13,23.59 204.07,23.59 200.39,27.27 198.81,27.27 196.42,29.66 161.06,29.66 157.61,26.21 153.57,26.21 153.24,25.87 132.12,25.87 131.51,26.48 111,26.48 109.19,28.29 99.72,28.29 96.39,31.61 94.65,31.61 89.99,36.27 89.99,57.09 92.94,60.04 92.94,61.41 v2(93.47,61.94)
  BOTTOM w0.127: R161.2 72.52,207.28 73.66,208.42 73.66,215.93 75.39,217.66 81.69,217.66 95.56,203.8 96.24,203.12 96.24,166.78 93.65,164.19 92.33,162.86 90.32,160.86 89.85,160.39 75.51,146.05 75.51,116.55 76.91,115.15 76.91,64.07 79.36,61.63 93.16,61.63 v2(93.47,61.94)
BMC_GPIO4: length 450.6
  L08_SIG2 w0.127: v2(85.98,60.39) 85.98,37.71 96.44,27.24 109.04,27.24 110.67,25.62 131.19,25.62 131.78,25.03 153.64,25.03 153.96,25.35 157.92,25.35 161.38,28.82 194.71,28.82 194.75,28.78 194.81,28.78 201.12,22.47 262.16,22.47 265.82,26.14 265.82,39.75 269.11,43.03 278.42,43.03 281.69,39.77 284.73,39.77 286.26,38.24 289.69,38.24 291.59,36.34 293.93,36.34 299.41,30.86 301.45,30.86 JP1.90
  BOTTOM w0.127: v2(85.98,60.39) 85.39,60.97 78.99,60.97 76.43,63.54 76.43,114.95 75.03,116.35 75.03,146.36 95.68,167.01 95.68,202.88 95.33,203.24 93.65,204.92 84.51,204.92 83.39,203.8 79.04,203.8 78.87,203.98 78.87,205.39 78.61,205.64 R163.2
BMC_GPIO5: length 471.2
  L08_SIG2 w0.127: JP1.93 296.04,30.78 296.04,33.23 293.44,35.83 291.59,35.83 289.56,37.86 285.02,37.86 283.45,39.42 281.63,39.42 278.28,42.78 269.2,42.78 266.06,39.65 266.06,25.98 262.27,22.19 201.06,22.19 194.71,28.54 194.65,28.54 194.61,28.58 161.48,28.58 158.02,25.11 155.35,25.11 154.03,23.79 132.63,23.79 131.08,25.34 110.52,25.34 108.94,26.91 96.38,26.91 84.86,38.43 84.86,58.89 v2(81.13,62.63)
  BOTTOM w0.127: R160.2 70.99,205.24 71.88,206.13 71.88,207.28 73.38,208.78 73.38,216.04 75.28,217.94 81.58,217.94 81.81,217.94 95.68,204.08 96.52,203.23 96.52,166.66 93.93,164.07 92.61,162.75 90.6,160.74 89.64,159.78 75.76,145.89 75.76,116.65 77.15,115.25 77.15,64.34 79.38,62.12 80.62,62.12 v2(81.13,62.63)
BMC_GPIO6: length 439.3
  TOP w0.127: v2(78.92,178.7) 77.22,180.41 77.22,185.6 77.01,185.81 77.01,186.3 76.33,186.98 R221.2
  L08_SIG2 w0.127: v2(81.71,59.53) 84.58,56.66 84.58,38.31 96.26,26.63 108.79,26.63 110.46,24.96 125.34,24.96 126.76,23.54 154.18,23.54 155.41,24.77 158.01,24.77 161.58,28.34 194.51,28.34 201.08,21.77 262.96,21.77 266.31,25.12 266.31,39.55 269.3,42.53 278.03,42.53 281.49,39.07 283.41,39.07 284.9,37.58 286.16,37.58 289.05,34.69 289.05,33.54 296.82,25.78 301.45,25.78 JP1.94
  BOTTOM w0.127: v2(78.92,178.7) 80.65,176.98 86.79,176.98 89.29,174.47 89.87,174.47 91.06,175.67 93.55,175.67 94.31,174.91 94.31,167.25 68.17,141.11 68.17,137.91 65.64,135.38 65.64,125.05 75.91,114.79 75.91,63.27 79.65,59.53 v2(81.71,59.53)
BMC_GREEN_LED: length 79.7
  TOP w0.102: U20.L2 69.41,195.73 v1(69.19,195.52)
  TOP w0.127: R41.2 v2(28.07,236.78)
  L03_SIG1 w0.102: 71.88,202.55 73.84,200.59 73.84,199.44 73.41,199.01 73.41,197.88 73.03,197.51 71.88,197.51 71.67,197.3 70.97,197.3 v1(69.19,195.52)
  L03_SIG1 w0.127: 71.88,202.55 70.27,204.15 60.96,204.15 58.83,202.02 56.41,202.02 53.85,204.59 v2(53.85,205.12)
  L08_SIG2 w0.127: v2(53.85,205.12) 53.85,206.07 53.55,206.38 51.73,206.38 34.91,223.2 34.49,223.2 34.03,223.67 34.03,224.08 30.95,227.15 30.95,233.89 v2(28.07,236.78)
  BOTTOM w0.127: R41.2 v2(28.07,236.78)
BMC_HDMI_RSTN: length 41.1
  TOP w0.102: U20.L18 79.23,195.43 80.24,195.43 80.26,195.46 80.45,195.46 80.49,195.42 80.51,195.42
  TOP w0.127: 80.51,195.42 81.63,194.3 84.09,194.3 84.77,193.61 85.15,193.61 85.35,193.82 v2(85.6,193.82) ; U35.4 v2(88.92,168.34)
  L08_SIG2 w0.127: v2(85.6,193.82) 85.6,193.82 85.22,193.44 84.2,193.44 83.88,193.12 83.88,189.76 83.88,171.43 86.2,169.12 88.15,169.12 v2(88.92,168.34)
  BOTTOM w0.127: v2(85.6,193.82) 87.13,193.82 87.77,193.18 R662.1
BMC_HIBN: length 17.5
  TOP w0.127: U20.M17 v1(78.43,195.67) ; TP98.1 v2(80.39,183.66)
  L03_SIG1 w0.102: 78.94,192.34 78.94,195.16 v1(78.43,195.67)
  L03_SIG1 w0.127: v2(80.39,183.66) 79.95,183.66 79.69,183.91 77.47,183.91 76.96,184.42 76.96,188.36 77.17,188.56 77.17,190.57 78.94,192.34
BMC_I2C0_SCL: length 5.4
  TOP w0.127: R844.2 R118.1 68.45,217.45 67.89,216.89 U14.2
BMC_I2C0_SDA: length 6
  TOP w0.127: U14.3 67.24,216.59 66.93,216.9 R117.1 66.38,217.55 66.18,217.35 65.24,217.35 65.06,217.53 R845.2
BMC_I2C1_SCL: length 34.6
  TOP w0.127: U16.7 v2(78.3,208.27)
  L03_SIG1 w0.127: v2(84.96,194.07) 84.96,194.52 85.92,195.47 v2(90.17,195.47)
  L08_SIG2 w0.127: v2(90.17,195.47) 90.79,196.09 90.79,197.45 90.39,197.86 90.25,197.86 88.09,200.02 88.09,205.32 85.14,208.27 v2(78.3,208.27)
  BOTTOM w0.127: R661.2 85.09,191.4 85.47,191.78 85.47,192.8 84.96,193.31 v2(84.96,194.07) R200.1
BMC_I2C1_SDA: length 33.2
  TOP w0.127: R663.2 84.94,192.52 v2(84.96,192.55) ; U16.6 v2(77.65,207.49)
  L03_SIG1 w0.127: v2(84.96,192.55) 85.53,193.12 85.79,193.12 86.61,193.94 v2(90.04,193.94)
  L08_SIG2 w0.127: v2(77.65,207.49) 78.24,207.49 78.73,207.98 84.92,207.98 87.66,205.25 87.66,200.06 89.08,198.64 89.08,197.41 89.66,196.83 89.66,194.32 v2(90.04,193.94)
  BOTTOM w0.127: R203.1 84.71,192.8 v2(84.96,192.55)
BMC_INT1: length 155.9
  TOP w0.127: U1.D14 v1(181.21,118.61) ; U24.15 91.67,185.28 91.95,185.56 92.84,185.56 93.34,185.05 v2(93.6,185.05)
  L03_SIG1 w0.102: 161.21,111.82 163.47,111.82 165.07,113.43 167.06,113.43 167.21,113.58 167.21,113.95 167.45,114.19 167.8,114.19 168.03,114.42 168.03,118.32 168.83,119.12 168.83,119.57 169.08,119.83 180,119.83 v1(181.21,118.61)
  L03_SIG1 w0.127: v2(93.6,185.05) 93.34,185.05 93.09,184.8 93.09,183.53 93.34,183.28 93.34,182.26 94.11,181.5 94.11,179.47 93.22,178.58 93.22,173.88 102.68,164.42 102.68,136.23 130.98,107.93 144.1,107.93 144.14,107.96 150.8,107.96 151.97,109.13 155.65,109.13 156.77,110.25 159.63,110.25 160.36,110.97 160.36,110.97 161.21,111.82
BMC_ISOL_EN1: length 23.6
  TOP w0.127: v2(88.14,186.2) 88.14,185.41 88.17,185.38 U24.22 ; U20.K15 77.83,196.63 77.83,196.79 v1(77.82,196.79)
  L03_SIG1 w0.102: 80.9,195.98 80.43,195.98 80.1,196.31 78.25,196.31 77.83,196.73 77.83,196.79 v1(77.82,196.79)
  L03_SIG1 w0.127: 80.9,195.98 82.68,195.98 83.44,195.21 83.44,190.9 v2(88.14,186.2)
  BOTTOM w0.127: R228.2 88.62,184.16 88.14,184.65 v2(88.14,186.2) R859.1
BMC_ISOL_EN2: length 34.4
  TOP w0.127: U20.K17 78.16,196.23 v1(77.9,195.98) ; U35.22 88.42,173.35 88.44,173.37 88.44,173.8 88.14,174.11 85.81,174.11 84.96,174.96 R272.2 84.02,176.02 83.99,176.05 R860.1 83.44,178.96 81.92,180.48 81.92,182.46 81.1,183.27 v2(81.12,183.27)
  L03_SIG1 w0.102: v1(77.9,195.98) 78,196.08 78.89,196.08 79.53,195.44 79.53,190.34 79.35,190.16 79.2,190.16
  L03_SIG1 w0.127: 79.2,190.16 77.72,188.69 77.72,184.93 78.11,184.55 80.65,184.55 80.95,184.24 80.95,183.44 81.12,183.27 v2(81.12,183.27)
BMC_ISOL_EN3: length 28.1
  TOP w0.102: 76.73,190.16 75.65,191.24 75.65,191.95 U20.V12
  TOP w0.127: R862.1 81.29,176.05 81.03,175.78 81.03,175.16 80.85,174.98 v2(80.4,174.98) U30.14 ; U30.15 v2(79.62,175.63) ; 76.73,190.16 77.06,189.83 77.06,186.96 77.85,186.17 79.01,186.17 v2(79.1,186.08)
  L08_SIG2 w0.127: v2(79.62,175.63) 79.62,185.56 v2(79.1,186.08)
  BOTTOM w0.127: R686.2 78.59,174.98 v2(80.4,174.98) 80.4,175.52 80.29,175.63 v2(79.62,175.63)
BMC_ISOL_EN4: length 30.5
  TOP w0.102: U20.U14 v2(76.48,192.73)
  TOP w0.127: U33.22 60.48,175.5 59.98,176 v2(59.98,176.24) ; v2(59.98,176.24) 58.98,176.24 58.8,176.42 R861.1 ; v2(59.98,176.24) 59.89,176.33 59.89,176.7 60.32,177.13 R263.2
  L03_SIG1 w0.102: 75.84,190.16 76.23,190.54 76.23,192.48 v2(76.48,192.73)
  L03_SIG1 w0.127: v2(59.98,176.24) 60.29,176.55 60.29,176.84 71.95,188.5 74.19,188.5 75.84,190.16
BMC_ISOL_EN5: length 35.9
  TOP w0.127: U31.14 v2(55,177.52) 55.85,177.52 R283.2 ; U20.R7 73.43,193.89 73.43,194.02 v1(73.53,194.12)
  L03_SIG1 w0.127: v1(73.53,194.12) 73.53,193.44 73.86,193.11 73.86,192.24 72.01,190.39 68.33,190.39 66.17,188.23 66.17,187.28 65.88,186.99 64.92,186.99 62.32,184.38 55.32,184.38 54.88,183.93 54.88,179.58 55.24,179.21 55.24,178.21 55,177.96 v2(55,177.52)
  BOTTOM w0.127: R283.2 55.85,177.52 v2(55,177.52)
BMC_JTAG_TCK: length 27.1
  TOP w0.102: v2(77.51,201.92) 77.67,201.76 77.67,201.31 77.43,201.07 U20.B15
  L03_SIG1 w0.102: v2(77.51,201.92) 77.93,202.34 77.93,202.55
  L03_SIG1 w0.127: 77.93,202.55 77.93,203.41 77.93,203.72 80.23,206.02 82.69,206.02 83.21,206.54 93.24,206.54 v2(94.11,207.41)
  BOTTOM w0.127: R639.1 97.03,204.48 v2(94.11,207.41)
BMC_JTAG_TDI: length 39.4
  TOP w0.127: U20.D14 76.91,199.21 v1(76.91,198.74)
  L03_SIG1 w0.102: 78.31,202.55 78.31,202.4 78.18,202.27 78.18,201.93 76.91,200.66 v1(76.91,198.74)
  L03_SIG1 w0.127: J7.3 98.96,215.43 95.89,212.36 95.89,207.71 94.44,206.26 93.5,206.26 93.4,206.16 83.49,206.16 82.97,205.64 80.39,205.64 78.31,203.57 78.31,202.55
BMC_JTAG_TDO: length 35.8
  TOP w0.127: v2(97.41,208.55) 97.16,208.29 R878.1 ; v1(77.44,199.2) 77.44,199.22 U20.C14
  L03_SIG1 w0.102: v1(77.44,199.2) 77.44,200.7 78.44,201.69 78.44,202.24 78.51,202.31 78.51,202.42 78.55,202.45 78.55,202.55
  L03_SIG1 w0.127: 78.55,202.55 78.55,203.46 80.45,205.36 83.14,205.36 83.69,205.92 87.59,205.92 87.99,205.53 94.72,205.53 97.41,208.22 v2(97.41,208.55) 99.21,210.35 J7.7
BMC_JTAG_TMS: length 62.9
  TOP w0.102: U20.C15 77.79,199.73 v1(77.83,199.76)
  TOP w0.127: v2(99.19,200.55) 99.19,198.39 98.17,197.37 R188.1
  L03_SIG1 w0.102: 78.79,202.55 78.79,202.45 78.75,202.42 78.75,202.37 78.74,202.36 78.74,201.56 77.83,200.65 v1(77.83,199.76)
  L03_SIG1 w0.127: 78.79,202.55 78.79,203.14 80.77,205.12 83.24,205.12 83.49,205.37 85.8,205.37 86.23,204.94 87.78,204.94 88.11,205.27 97.66,205.27 99.01,203.93 99.01,200.73 v2(99.19,200.55) 107.19,200.55 108.46,201.82 108.46,215.66 107.44,216.68 105.46,216.68 J7.1
BMC_JTAG_TRSTN: length 33.2
  TOP w0.127: J7.2 108.08,216.6 108.08,200.17 104.52,196.61 98.81,196.61 98.41,196.21 R786.1 97.54,194.83 97.28,194.58 TP176.1
BMC_LCD_A0: length 48.6
  TOP w0.102: v1(69.3,198.13) 70.33,198.13 U20.F1
  L03_SIG1 w0.102: v1(69.3,198.13) 68.83,198.6
  L03_SIG1 w0.127: v2(51.94,209.44) 51.18,208.68 51.18,205.34 51.18,205.07 55.63,200.62 61.29,200.62 62.23,199.68 67.75,199.68 68.83,198.6
  L08_SIG2 w0.127: v2(51.94,209.44) 52.26,209.75 55.41,209.75 56.25,210.59 56.26,210.59 56.6,210.94 56.63,210.94 57.12,211.43 57.12,211.46 58.99,213.33 58.99,213.34 59.05,213.4 59.05,219.72 61.82,222.49 62.42,222.49 MOD1.15
BMC_LCD_RSTN: length 51.3
  TOP w0.102: 68.83,198.77 68.88,198.77 69.14,198.5 69.15,198.51 69.46,198.51 70.65,198.51 U20.F2
  TOP w0.127: 68.83,198.77 v2(64.77,198.77)
  L03_SIG1 w0.127: v2(51.18,209.44) 50.8,209.06 50.8,204.97 55.42,200.34 61.18,200.34 62.75,198.77 v2(64.77,198.77)
  L08_SIG2 w0.127: MOD1.16 63.31,221.88 62.79,221.88 60.71,219.8 60.71,219.27 59.77,218.33 59.77,213.66 55.05,208.94 51.68,208.94 v2(51.18,209.44)
BMC_LRESETN: length 33.4
  TOP w0.102: U20.C18 79.72,199.73 79.77,199.78
  TOP w0.127: 79.77,199.78 80.26,200.28 v1(80.26,201.18) ; v2(87.67,179.39) 88.17,179.89 U24.3
  L08_SIG2 w0.102: 80.9,199.79 80.26,200.42 v1(80.26,201.18)
  L08_SIG2 w0.127: 80.9,199.79 81.53,199.15 85.73,199.15 85.74,199.14 86.6,199.14 87.68,198.06 87.68,196.83 88.42,196.09 88.42,190.54 87.08,189.21 87.08,185.76 87.17,185.67 87.17,180.49 87.17,180.49 87.17,180.08 87.17,180.07 87.17,179.88 v2(87.67,179.39)
BMC_LRESETNMIENN: length 34.2
  TOP w0.102: U20.B18 79.23,199.93 79.58,199.93 79.63,199.98
  TOP w0.127: U24.4 v2(88.67,180.28) ; v1(79.63,202.58) 79.63,202.07 79.86,201.84 79.86,200.21 79.63,199.98
  L08_SIG2 w0.127: v2(88.67,180.28) 88.67,181.08 87.73,182.02 87.73,185.9 87.64,185.99 87.64,188.98 88.98,190.31 88.98,193.56 88.9,193.64 88.9,196.4 88.24,197.06 88.24,198.29 86.83,199.7 85.97,199.7 85.96,199.71 85.45,199.71 84.61,200.55 82.94,200.55 80.91,202.58 v1(79.63,202.58)
BMC_MLB_RSTN: length 56.4
  TOP w0.127: U20.G15 77.21,197.73 v1(77.04,197.91) ; U35.10 v2(91.92,168.34)
  L08_SIG2 w0.127: v2(91.92,168.34) 92.44,167.82 92.44,167.24 91.86,166.65 87.47,166.65 83.54,170.59 83.05,171.08 83.05,183.9 83.05,185.83 81.79,187.09 81.79,189.83 83.05,191.09 83.05,195.2 84.28,196.43 85.81,196.43 v2(86.01,196.23)
  BOTTOM w0.102: 80.9,198.13 80.11,197.35 78.15,197.35 78.08,197.42 77.52,197.42 v1(77.04,197.91)
  BOTTOM w0.127: R659.1 87.77,196.23 87.54,196.46 86.24,196.46 v2(86.01,196.23) 86.01,196.67 86.09,196.75 86.09,197.45 85.78,197.77 85.23,197.77 84.43,198.57 81.33,198.57 80.9,198.13
BMC_NMIN: length 39.2
  TOP w0.127: R180.1 82.15,199.64 82.42,199.91 v2(82.42,199.81) ; U20.G16 v1(78.31,197.73) ; v2(88.67,179.39) 89.17,179.89 U24.5
  L08_SIG2 w0.127: v2(88.67,179.39) 88.17,179.89 88.17,180.78 87.45,181.49 87.45,185.79 87.36,185.88 87.36,189.09 88.7,190.42 88.7,193.5 88.66,193.54 88.66,196.25 87.96,196.95 87.96,198.17 86.72,199.42 85.85,199.42 85.84,199.43 85.24,199.43 84.43,200.24 82.86,200.24 v2(82.42,199.81)
  BOTTOM w0.102: v1(78.31,197.73) 80.1,197.73 80.9,198.53
  BOTTOM w0.127: R655.2 85.71,199.77 85.09,199.15 83.08,199.15 v2(82.42,199.81) 82.18,199.81 80.9,198.53
BMC_OSC0: length 13.4
  TOP w0.102: U20.E19 79.97,198.73 80.9,199.66
  TOP w0.127: 80.9,199.66 81.23,199.66 82.37,200.8 83.81,200.8 84.45,200.15 R171.2 86.1,200.15 86.72,200.77 C80.1 86.72,200.97 87.21,201.46 89.91,201.46 90.11,201.26 Y3.1
BMC_OSC1: length 10.5
  TOP w0.127: U20.D19 80.13,199.23 80.8,199.9 81.09,199.9 82.64,201.45 R171.1 85.68,201.45 86.72,202.49 C72.1 86.74,202.56 Y3.3
BMC_PCIE_RSTN: length 41.8
  TOP w0.102: U20.N19 80.11,194.73 80.9,193.94 80.9,193.92
  TOP w0.127: 80.9,193.92 81.15,193.66 81.15,192.47 81.97,191.66 85.55,191.66 85.83,191.38 86.5,191.38 v2(86.78,191.66) 86.8,191.68 R202.1 ; U35.9 91.42,167.95 v2(90.92,167.45)
  L08_SIG2 w0.127: v2(90.92,167.45) 91.42,167.96 91.42,168.57 88.93,171.07 86.53,171.07 85,172.6 85,189 86.6,190.6 86.6,191.48 v2(86.78,191.66)
BMC_PORN: length 79.2
  TOP w0.127: v2(88.39,156.86) 86.74,155.21 74.24,155.21 J16.2 ; U24.8 v2(90.67,180.28) ; U20.G19 81.04,197.73 v1(81.27,197.5)
  L08_SIG2 w0.127: v2(88.39,156.86) 92.84,161.3 92.84,174.48 93.08,174.72 93.08,175.29 91.57,176.8 91.57,179.38 v2(90.67,180.28) 90.17,180.78 89.46,180.78 89.16,180.48 89.16,179.19 88.87,178.9 87.46,178.9 85.86,180.49 85.86,188.38 88.14,190.66 88.14,195.98 87.4,196.72 87.4,197.02 85.56,198.86 84.95,198.86 83.59,197.5 v1(81.27,197.5)
BMC_QSPI_RSTN: length 43
  TOP w0.102: U20.L19 79.5,195.66 80.66,195.66 80.68,195.65
  TOP w0.127: v2(87.92,167.45) 88.42,167.95 U35.3 ; v2(86.01,194.71) 86.01,194.72 85.8,194.93 85.52,194.93 85.32,194.73 81.59,194.73 80.68,195.65
  L08_SIG2 w0.127: v2(87.92,167.45) 87.46,167.45 83.77,171.15 83.6,171.31 83.6,184.13 83.6,194.36 83.92,194.68 85.99,194.68 v2(86.01,194.71)
  BOTTOM w0.127: R660.1 87.77,194.71 87.25,195.23 86.54,195.23 v2(86.01,194.71)
BMC_RESET_FULLN: length 35.7
  TOP w0.127: U20.H19 79.52,197.32 80.47,197.32 80.83,196.96 v1(80.83,196.93) ; U24.6 v2(89.67,180.28)
  L08_SIG2 w0.127: v2(89.67,180.28) 90.16,179.79 90.16,179.19 89.31,178.34 87.23,178.34 85.31,180.26 85.31,188.72 87.58,191 87.58,195.75 86.6,196.73 84.13,196.73 82.37,194.97 81.75,194.97 80.72,196 80.72,196.82 v1(80.83,196.93)
BMC_RESETZ: length 78
  TOP w0.102: 79.96,193.92 79.24,193.92 U20.P18
  TOP w0.127: v1(80.21,193.66) 79.96,193.92 ; v2(92.71,203.89) 94.87,203.89 95.12,204.14 95.12,213.88 101.78,220.54 101.78,231.26 97.16,235.88 R885.2 97.78,236.98 98.04,237.25 98.04,238.01 98.3,238.27 D9.1 100.7,238.27 C799.1 R254.1
  BOTTOM w0.102: v1(80.21,193.66) 79.63,194.25 79.63,195.52 78.79,196.36 76.23,196.36 75.82,196.76 75.82,197.91 75.62,198.11 75.13,198.11 74.93,198.31 74.93,200.04 75.34,200.45 77.55,200.45 78.26,201.16
  BOTTOM w0.127: v2(92.71,203.89) 84.72,203.89 83.83,203 79.29,203 78.38,202.1 78.38,201.28 78.26,201.16
BMC_RSV6_TOGGLE: length 44.1
  TOP w0.127: v1(74.45,199.1) 74.45,199.21 74.32,199.34 74.28,199.34 74.05,199.57 74.05,199.61 U20.C8 ; v2(60.07,169.43) 60.48,169.84 U33.3
  L08_SIG2 w0.127: v2(60.07,169.43) 59.68,169.43 58.12,171 58.12,178.03 66.75,186.67 66.75,194.82 66.96,195.02 66.96,195.05 66.96,196.65 68.85,198.54 69.53,198.54 69.56,198.58 69.58,198.58 69.81,198.81 69.81,198.83 71.18,200.19 72.09,200.19 73.18,199.1 v1(74.45,199.1)
BMC_SOC_RESETN: length 34.4
  TOP w0.102: 80.9,196.48 80.65,196.48 80.39,196.74 80.39,196.99 80.31,197.07 79.67,197.07 79.55,196.95 79.21,196.95 U20.H18
  TOP w0.127: 80.9,196.48 v1(81.28,196.48) ; U24.7 90.17,179.89 v2(89.67,179.39)
  L08_SIG2 w0.127: v2(89.67,179.39) 89.67,179.3 88.99,178.62 87.35,178.62 85.59,180.38 85.59,188.5 87.86,190.77 87.86,195.86 85.97,197.75 84.58,197.75 83.31,196.48 v1(81.28,196.48)
BMC_SPI0_CLK: length 14.3
  TOP w0.127: R220.2 73.03,184.55 74.04,183.53 74.04,174.58 73.79,174.33 U30.4
BMC_SPI0_CS0N: length 35.4
  TOP w0.127: U20.U5 72.03,192.73 v1(72.02,192.73) ; U31.6 v2(46.11,175.57)
  L03_SIG1 w0.127: v1(72.02,192.73) 72.02,192.31 71.49,191.78 68.43,191.78 61.82,185.18 54.99,185.18 54.1,184.29 54.1,183.56 v2(46.11,175.57)
BMC_SPI0_MISO: length 29.7
  TOP w0.127: v2(66.55,184.93) 66.55,188.1 66.68,188.23 R667.2 R232.2 ; U30.6 v2(71.51,173.03)
  BOTTOM w0.127: v2(71.51,173.03) 71.85,173.37 75.06,173.37 75.44,173.75 75.44,178.32 74.04,179.72 67.95,179.72 66.55,181.12 v2(66.55,184.93)
BMC_SPI0_MOSI: length 28.5
  TOP w0.127: U30.5 v2(70.73,173.68)
  BOTTOM w0.127: v2(70.73,173.68) 71.31,174.26 74.3,174.26 74.8,174.77 74.8,177.94 73.41,179.34 67.44,179.34 65.91,180.86 65.91,186.07 66.55,186.7 R666.2 R231.2
BMC_SPI1_CLK: length 49.1
  TOP w0.102: 72.93,201.12 71.49,202.55
  TOP w0.127: 71.49,202.55 69.85,202.55 v2(68.83,203.57) ; U20.B6 72.93,201.12
  L03_SIG1 w0.127: v2(68.83,203.57) 67.74,202.48 60.71,202.48 59.56,201.34 56.13,201.34 52.2,205.27 52.2,207.99 54.46,210.25 v2(54.46,210.91)
  L08_SIG2 w0.127: v2(54.46,210.91) 56.03,210.91 56.09,210.97 56.1,210.97 56.44,211.32 56.48,211.32 56.74,211.59 56.74,211.62 58.67,213.55 58.67,220.24 MOD1.14
BMC_SPI1_CSN: length 58.7
  TOP w0.127: U20.C6 72.63,199.43 v1(71.96,199.43)
  L03_SIG1 w0.102: 68.83,201.93 69.99,201.93 71.96,199.96 v1(71.96,199.43)
  L03_SIG1 w0.127: v2(51.94,210.71) 52.44,210.21 52.44,209.23 52.15,208.94 52.14,208.94 51.46,208.26 51.46,205.22 55.78,200.9 60.29,200.9 61.32,201.93 68.83,201.93
  L08_SIG2 w0.127: MOD1.17 61.89,218.96 61.19,218.96 60.45,218.23 60.45,213.95 55.16,208.66 51.26,208.66 50.69,209.23 50.69,209.64 51.75,210.71 v2(51.94,210.71)
BMC_SPI1_MOSI: length 38.5
  TOP w0.127: R177.1 R170.1 v2(64.77,203.34)
  L03_SIG1 w0.127: v2(64.77,203.34) 60.68,203.34 59.11,201.77 56.29,201.77 52.84,205.21 52.84,206.09 56.29,209.53 v2(56.29,211.77)
  L08_SIG2 w0.127: v2(56.29,211.77) 56.29,212.97 58.29,214.98 58.29,220.4 58.33,220.44 58.33,221.4 MOD1.13
BMC_SYSCLKSEL: length 46.8
  TOP w0.127: v1(72.09,195.9) 72.1,195.9 U20.K5 ; U33.10 v2(63.98,170.25)
  L03_SIG1 w0.127: v2(63.98,170.25) 64.64,169.58 64.64,160.92 61.82,158.1 J15.2 ; v2(68.35,193.08) 69.67,193.08 70.61,194.02 70.61,194.76 71.04,195.19 71.53,195.19 71.89,195.56 71.89,195.71 v1(72.09,195.9)
  L08_SIG2 w0.127: v2(68.35,193.08) 68.35,192.61 68.02,192.28 68.02,173.13 67.81,172.91 67.81,172.9 65.34,170.42 65.32,170.42 65.14,170.25 v2(63.98,170.25)
BMC_TSC_WAKEN: length 42.8
  TOP w0.102: U20.M18 80.36,195.23
  TOP w0.127: v2(89.92,167.45) 90.42,167.95 U35.7 ; 80.36,195.23 81.53,194.06 83.96,194.06 84.65,193.37 85.24,193.37 86.06,192.56 v2(86.06,192.34)
  L08_SIG2 w0.127: v2(86.06,192.34) 85.61,192.34 84.44,191.17 84.44,188.5 84.44,171.66 86.43,169.67 89.32,169.67 90.42,168.57 90.42,167.96 v2(89.92,167.45)
  BOTTOM w0.127: v2(86.06,192.34) 87.09,192.34 87.77,191.66 R664.1
BMC_TXVR_RXD: length 33.7
  TOP w0.127: U13.9 v2(23.51,222.91) ; v2(47.14,209.9) 47.14,209.64 46.67,209.17 U130.4
  L08_SIG2 w0.127: v2(47.14,209.9) 46.64,209.39 45.73,209.39 45.49,209.63 36.59,209.63 27.13,219.09 27.13,220.66 26.04,221.76 24.66,221.76 v2(23.51,222.91)
BMC_TXVR_TXD: length 29.5
  TOP w0.127: v2(46.25,209.9) 45.92,209.57 U130.5 ; U13.11 v2(24.81,222.81)
  L08_SIG2 w0.127: v2(24.81,222.81) 26.17,222.81 30,218.99 30,218.18 37.08,211.09 45.06,211.09 v2(46.25,209.9)
BMC_UART0_CP2105_EN: length 11.9
  TOP w0.203: v2(30.89,207.86) 31.09,208.07 U129.2
  TOP w0.381: U101.4 37.63,204.42 37.49,204.56 v2(37.49,205.32)
  L03_SIG1 w0.381: v2(30.89,207.86) 36.22,207.86 37.49,206.59 v2(37.49,205.32)
BMC_UART0_DETECT: length 94.3
  TOP w0.102: U20.T2 70.65,192.95 70.04,192.95 68.96,191.87 68.83,191.87
  TOP w0.127: U101.2 44.45,203.77 v2(44.98,204.31) 44.65,204.64 U130.2 ; v2(21.97,220.11) 21.66,220.42 21.66,221.2 R132.2 19.56,221.25 18.92,221.88 18.92,232.17 18.24,232.86 J6.1 ; 68.83,191.87 67.94,191.87 67.35,191.28 v2(63.5,191.28)
  L08_SIG2 w0.127: v2(21.97,220.11) 25.6,220.11 33.49,212.22 33.49,211.05 36.91,207.63 41.66,207.63 v2(44.98,204.31) 45.3,203.99 45.3,198.02 45.25,197.97 52.2,191.02 59.82,191.02 60.96,192.17 62.61,192.17 v2(63.5,191.28)
BMC_UART0_EN: length 3.7
  TOP w0.127: U13.1 v2(28.06,230.95) 28.06,232.14 R103.1
  BOTTOM w0.127: R103.1 28.06,232.14 v2(28.06,230.95)
BMC_UART0_RX: length 51.9
  TOP w0.127: U130.9 42.98,209.17 v2(42.44,208.63) ; U20.V3 71.44,192.24 v1(71.44,192.72) ; U129.9 v2(32.95,210.15)
  L03_SIG1 w0.127: v1(71.44,192.72) 70.91,192.19 67.89,192.19 66.32,193.77 66.32,195.75 66,196.07 63.77,196.07 62.75,195.05 61,195.05 58.42,197.63 v2(58.42,199.4) ; v2(32.95,210.15) 38.79,210.15 40.31,208.63 v2(42.44,208.63)
  L08_SIG2 w0.127: v2(58.42,199.4) 58.11,199.72 55.06,199.72 46.15,208.63 v2(42.44,208.63)
BMC_UART0_TX: length 60.6
  TOP w0.102: U20.W3 71.12,191.42
  TOP w0.127: U130.8 42.11,209.57 v2(41.68,209.13) ; U129.8 33.35,209.92 33.4,209.97 33.4,210.82 v2(33.05,211.17) ; v2(64.63,189.24) 65.07,189.24 65.29,189.03 69.35,189.03 70.15,189.84 70.15,190.45 71.12,191.42
  L03_SIG1 w0.127: v2(33.05,211.17) 38.91,211.17 40.94,209.13 v2(41.68,209.13)
  L08_SIG2 w0.127: v2(41.68,209.13) 41.68,208.6 42.44,207.84 45.62,207.84 48.46,204.99 48.46,195.72 52.65,191.53 59.93,191.53 60.84,192.45 63.03,192.45 64.63,190.85 v2(64.63,189.24)
BMC_UART1_RX: length 122
  TOP w0.127: R166.2 v2(79.25,206.67) ; v2(48.01,113.12) 45.8,113.12 45.14,113.78 U76.9
  L08_SIG2 w0.127: v2(79.25,206.67) 78.89,207.02 78.5,207.02 78.42,207.1 78.04,207.1 77.97,207.02 76.59,207.02 76.24,206.67 73.54,206.67 65.35,198.48 65.35,196.79 64.72,196.15 64.72,191.73 65.15,191.3 65.15,189.07 64.29,188.2 64.29,187.63 58.48,181.83 54.53,181.83 53.16,180.46 53.16,163.64 54.71,162.09 54.71,114.29 53.47,113.04 48.08,113.04 v2(48.01,113.12)
BMC_UART1_TX: length 122.4
  TOP w0.127: U76.8 44.74,113.11 v2(44.82,113.03) ; v2(78.23,206.64) 77.6,206.01 R174.2
  L08_SIG2 w0.127: v2(78.23,206.64) 77.7,206.11 75.46,206.11 73.68,204.33 71.6,204.33 65.61,198.34 65.61,196.61 64.96,195.96 64.96,191.87 65.43,191.4 65.43,188.88 64.57,188.01 64.57,187.52 58.9,181.85 58.85,181.85 58.57,181.57 54.62,181.57 53.44,180.39 53.44,163.87 54.99,162.32 54.99,113.81 53.72,112.54 45.31,112.54 v2(44.82,113.03)
BMC_UART_SEL: length 129.3
  TOP w0.102: v2(63.98,190.49) 64.36,190.87 67.28,190.87 68,191.58 69.01,191.58 70.16,192.73 U20.U2
  TOP w0.127: v2(38.5,104.04) R914.2 R915.2 ; U76.2 46.73,115.45 v2(47.04,115.76) 47.48,115.76 48.39,116.66 48.39,118.63 48.01,119.01 44.32,119.01 44.07,119.27 44.07,120.18 43.97,120.28 U68.2
  L08_SIG2 w0.127: v2(63.98,190.49) 64.01,190.46 64.01,187.75 58.39,182.13 54.28,182.13 52.88,180.74 52.88,163.36 54.43,161.81 54.43,119.58 50.61,115.76 v2(47.04,115.76) 46.72,116.07 39.99,116.07 38.5,114.58 v2(38.5,104.04)
BMC_WAKEN: length 25
  TOP w0.102: U20.U18 78.81,192.73 78.44,193.11 78.41,193.08 v1(78.41,193.05)
  BOTTOM w0.102: v1(78.41,193.05) 78.41,192.29 77.22,191.1 77.22,190.16
  BOTTOM w0.127: 77.22,190.16 77.22,189.42 78.05,188.58 79.4,188.58 81.04,190.22 91.15,190.22 91.82,190.9 91.82,193.31 J9.2
BMC_XOSC0: length 3.1
  TOP w0.127: R205.1 84.63,190.64 86.17,189.1 U21.3
BMC_XOSC0_R: length 5.1
  TOP w0.102: 80.9,191.84 80.39,192.34 80.39,192.9 79.78,193.51 79.25,193.51 78.97,193.23 U20.T18
  TOP w0.127: R205.2 82.09,190.64 80.9,191.84
BOOTMODEON: length 216.7
  TOP w0.102: 80.9,198.01 79.21,198.01 U20.G18
  TOP w0.127: U67.25 166.01,86.38 165.99,86.36 v2(165.99,85.92) ; U67.48 v2(175.21,86.63) ; v1(81.53,198.13) 81.41,198.01 80.9,198.01
  L08_SIG2 w0.102: 80.9,192.93 79.81,191.84
  L08_SIG2 w0.127: 80.9,192.93 81.23,193.26 81.23,194.5 80.34,195.39 80.34,197.24 81.24,198.13 v1(81.53,198.13) ; 79.81,191.84 79.81,191.37 80.16,191.01 80.16,189.17 78.24,187.24 78.24,161.43 78.36,161.3 78.36,161.04 105.3,134.11 107.98,131.43 107.98,97.44 108.73,96.69 108.73,96.59 113.23,92.09 113.23,91.34 115.61,88.97 135.1,88.97 136.96,87.11 155.12,87.11 155.8,86.43 163.68,86.43 163.7,86.45 164.11,86.45 164.13,86.43 165.48,86.43 v2(165.99,85.92) 166.54,85.37 173.96,85.37 v2(175.21,86.63)
  BOTTOM w0.127: R744.2 175.37,87.63 175.21,87.47 v2(175.21,86.63) 176.93,84.91 180.75,84.91 181.02,85.18 181.02,88.02 177.03,92 177.03,92.85 177.42,93.23 U66.2 ; v2(165.99,85.92) 166.31,85.6 166.38,85.6 166.62,85.36 R501.1
BT_EN: length 223.6
  TOP w0.127: v2(155.83,206.71) 187.62,206.71 189.99,209.08 189.99,214.75 191.59,216.35 194.84,216.35 196.3,214.89 U128.6 ; v2(89.43,108.37) 90.96,108.37 91.23,108.65 U51.7
  BOTTOM w0.127: v2(89.43,108.37) 88.99,108.37 87.81,109.55 87.81,150 98.97,161.16 98.97,176.21 98.07,177.1 98.07,180.56 99.09,181.57 99.09,187.39 100.03,188.33 107.96,188.33 109.72,190.08 109.72,191.13 109.49,191.36 109.49,212.93 111.78,215.22 122.43,215.22 130.94,206.71 v2(155.83,206.71)
BUF_CP2105_RXD: length 38.2
  TOP w0.127: U146.4 26.64,91.61 27.18,91.07 27.18,88.53 v2(26.8,88.15) ; U74.13 v2(24.11,59.72)
  L03_SIG1 w0.127: v2(26.8,88.15) 24.11,85.47 v2(24.11,59.72)
BUF_CP2105_TXD: length 43
  TOP w0.127: U146.5 27,92.01 27.56,91.45 27.56,88.41 v2(27.81,88.15) ; v2(24.89,58.31) 24.51,57.93 21.46,57.93 21.19,58.2 U74.12
  L03_SIG1 w0.127: v2(24.89,58.31) 25.53,58.94 25.53,85.87 v2(27.81,88.15)
BUF_ETH_RSTN: length 38.9
  TOP w0.127: U92.42 167.52,51.88 167.31,51.67 v2(167.31,51.69) 166.17,51.69 C336.1 ; R566.2 166.05,54.53 166.32,54.79 D4.2 v2(166.32,56.4) ; v2(178.25,40.51) R529.1 179.9,40.51 180.2,40.21 U88.4
  BOTTOM w0.127: v2(166.32,56.4) 166.32,55.49 167.64,54.17 167.64,52.02 v2(167.31,51.69) 165.39,51.69 163.93,50.23 163.93,47.11 170.53,40.51 v2(178.25,40.51)
BUF_I2C1_SCL: length 241.1
  TOP w0.127: U95.2 v2(293.43,33.9) 293.43,32.18 293.28,32.03 R550.2 ; R579.2 126.7,23.92 125.58,25.03 125.58,29.07 128.04,31.54 128.04,36.02 128.69,36.67 151.28,36.67 157.5,30.45 178.92,30.45 183.16,34.69 220.7,34.69 224.56,30.83 v2(225.73,30.83)
  L03_SIG1 w0.102: 280.7,40.35 278.1,42.94 271.37,42.94 270.61,43.7 269.88,43.7
  L03_SIG1 w0.127: 280.7,40.35 281.05,39.99 287.12,39.99 290.42,36.69 290.42,34.91 291.06,34.28 291.06,33.57 297.84,26.79 297.84,22.19 298.26,21.76 JP1.97 ; 269.88,43.7 266.95,43.7 265.18,41.92 265.18,30.11 262.28,27.22 260.38,27.22 260.01,27.59 259.73,27.59 v2(259.47,27.84)
  L08_SIG2 w0.127: v2(225.73,30.83) 226.06,30.49 230.45,30.49 234.16,26.79 241.07,26.79 241.3,27.02 248.78,27.02 248.78,27.02 258.65,27.02 v2(259.47,27.84)
  BOTTOM w0.127: v2(293.43,33.9) 293.43,33.45 293.45,33.43 293.45,28.64 299.97,22.11 JP1.97
BUF_I2C1_SDA: length 228.7
  TOP w0.127: U95.3 v2(294.08,33.5) 293.75,33.17 293.75,32.15 293.86,32.03 R557.2 ; R578.2 125.17,29.12 127.76,31.71 127.76,36.13 128.57,36.95 128.81,36.95 151.41,36.95 157.63,30.73 178.81,30.73 183.04,34.97 220.95,34.97 224.28,31.64 v2(225.04,31.64)
  L03_SIG1 w0.102: 280.7,41.04 278.54,43.19 271.78,43.19 270.97,44.01 269.88,44.01
  L03_SIG1 w0.127: v2(294.08,33.5) 293.89,33.31 292.69,33.31 290.83,35.18 290.83,36.77 290.17,37.43 290.14,37.43 287.2,40.38 281.36,40.38 280.7,41.04 ; v2(260.6,27.95) 260.77,28.12 262.52,28.12 264.74,30.34 264.74,42 266.75,44.01 269.88,44.01
  L08_SIG2 w0.127: v2(260.6,27.95) 259.97,28.59 258.95,28.59 257.66,27.29 241.17,27.29 240.92,27.04 234.42,27.04 230.13,31.32 225.36,31.32 v2(225.04,31.64)
  BOTTOM w0.127: v2(294.08,33.5) 294.64,32.94 294.64,27.95 299.47,23.13 301.15,23.13 JP1.98
BUF_MCASP0AHCLKX: length 21.4
  TOP w0.127: v2(297.05,61.36) 296.04,61.36 295.8,61.59 U139.4 ; R876.1 v2(296.8,51.16)
  L03_SIG1 w0.127: v2(297.05,61.36) 298.2,60.21 298.2,59.58 299.08,58.69 301.62,58.69 302.51,57.8 JP1.70
  L08_SIG2 w0.127: v2(296.8,51.16) 296.71,51.16 296.04,51.83 296.04,60.34 v2(297.05,61.36)
BUF_MCASP2ACLKX: length 159
  TOP w0.127: TP193.1 278,55.51 v2(278.38,55.13) 278.57,54.94 U69.5 ; v2(278.06,44.15) 277.84,43.93 U96.38
  L03_SIG1 w0.127: v2(278.38,55.13) 279.25,54.27 279.25,46.67 278.06,45.48 v2(278.06,44.15)
  L08_SIG2 w0.127: v2(198.78,145.48) 199.84,146.54 203.09,146.54 204.01,147.46 209.48,147.46 210,147.46 211.15,146.31 211.15,141.69 215.59,137.25 215.63,137.25 237.05,115.83 237.05,115.65 237.11,115.59 237.11,109.54 237.13,109.51 237.13,109.43 248.96,97.6 251.14,97.6 252.53,98.99 257.84,98.99 280.54,76.29 280.54,57.29 v2(278.38,55.13)
  BOTTOM w0.127: v2(198.78,145.48) 198.52,145.74 U136.13
BUF_MCASP2AXR2: length 155.9
  TOP w0.127: U96.40 276.84,43.74 276.87,43.77 v2(276.87,44.46) ; TP206.1 277.61,52.83 277.81,52.83 v2(278.34,53.36) 278.62,53.64 U69.7
  L03_SIG1 w0.102: v2(276.87,44.46) 276.87,45.79
  L03_SIG1 w0.127: v2(278.34,53.36) 278.51,53.2 278.51,47.51 276.87,45.87 276.87,45.79
  L08_SIG2 w0.127: v2(278.34,53.36) 277.24,54.47 277.24,78.71 257.58,98.36 253.14,98.36 251.75,96.98 247.16,96.98 236.37,107.77 236.37,115.63 215.37,136.63 215.33,136.63 210.53,141.43 210.53,146.05 209.74,146.84 204.36,146.84 203.25,145.73 201.63,145.73 v2(201.27,145.38)
  BOTTOM w0.127: v2(201.27,145.38) 200.86,145.79 200.05,145.79 199.82,146.01 U136.11
BUF_MCASP2AXR3: length 148.6
  TOP w0.127: v2(271.27,49.42) 272.03,50.18 TP207.1
  L08_SIG2 w0.127: v2(271.27,49.42) 275.87,54.02 275.87,79.68 257.47,98.08 253.36,98.08 251.97,96.69 247.06,96.69 234.95,108.8 234.95,116.71 215.27,136.39 215.23,136.39 210.29,141.33 210.29,141.39 209.6,142.08 v2(209.6,145.76)
  BOTTOM w0.127: v2(271.27,49.42) 271.65,49.04 271.65,45.1 273.81,42.94 R762.2 ; v2(209.6,145.76) 209.6,148.86 209.15,149.31 U137.3
BUF_MCASP2FSX: length 157.1
  TOP w0.127: U69.6 v2(278.38,54.29) 277.94,54.29 277.63,53.99 TP205.1 ; v2(277.62,44.85) 277.62,44.4 277.34,44.13 U96.39
  L03_SIG1 w0.102: 277.65,45.79 277.65,44.88 v2(277.62,44.85)
  L03_SIG1 w0.127: v2(278.38,54.29) 278.87,53.81 278.87,47.11 277.65,45.89 277.65,45.79
  L08_SIG2 w0.127: v2(199.67,145.48) 200.35,146.16 203.25,146.16 204.17,147.08 209.64,147.08 209.64,147.08 209.84,147.08 209.84,147.08 210.77,146.16 210.77,141.53 215.43,136.87 215.47,136.87 236.67,115.67 236.67,115.49 236.73,115.43 236.73,109.7 236.73,108.22 247.73,97.22 251.54,97.22 252.92,98.6 257.68,98.6 277.62,78.67 277.62,55.06 v2(278.38,54.29)
  BOTTOM w0.127: U136.12 199.17,146.01 199.67,145.51 v2(199.67,145.48)
BUF_MIPI_TCK: length 19.4
  TOP w0.127: R866.1 v2(219.33,97.3) ; v2(220.75,110.58) 220.75,110.56 221.43,109.88 U134.3
  L08_SIG2 w0.127: v2(219.33,97.3) 217.98,98.64 217.98,109.41 219.15,110.58 v2(220.75,110.58)
BUF_MIPI_TDI: length 20.9
  TOP w0.127: U132.20 219.85,92.94 219.98,93.07 v2(219.98,93.51) ; v2(224.56,108.02) 223.72,108.02 223.64,107.93 U134.6
  L08_SIG2 w0.127: v2(219.98,93.51) 220.93,94.47 220.93,97.7 220.75,97.88 220.75,100.5 220.09,101.16 220.09,102.29 224.56,106.76 v2(224.56,108.02)
BUF_MIPI_TMS: length 23.3
  TOP w0.127: v2(225.53,109.72) 226.01,109.23 U134.13 ; U132.18 220.85,92.68 221.08,92.92 v2(221.08,93.36)
  L08_SIG2 w0.127: v2(225.53,109.72) 225.45,109.64 225.45,108.04 225.68,107.81 225.68,105.74 223.14,103.2 223.14,102.44 221.41,100.72 221.41,98.41 221.49,98.34 221.49,93.77 v2(221.08,93.36)
BUF_MIPI_TRST#: length 20.9
  TOP w0.127: U134.10 226.36,107.28 226.31,107.33 v2(225.22,107.33) ; U132.19 220.35,92.46 220.47,92.59 v2(220.47,93.03)
  L08_SIG2 w0.127: v2(225.22,107.33) 225.22,107.03 221.09,102.9 221.09,98.02 221.21,97.91 221.21,94.21 220.47,93.47 v2(220.47,93.03)
BUF_MMC1_CLK: length 101.8
  TOP w0.127: U142.20 v2(213.53,213)
  L03_SIG1 w0.127: v2(213.53,213) 216.1,210.43 216.1,204.97 216.23,204.84 217.09,204.84 217.22,204.71 217.22,204.46 217.09,204.33 216.23,204.33 216.1,204.21 216.1,203.95 216.23,203.83 217.09,203.83 217.22,203.7 217.22,203.44 217.09,203.32 216.23,203.32 216.1,203.19 216.1,202.94 216.23,202.81 217.09,202.81 217.22,202.68 217.22,202.43 217.09,202.3 216.23,202.3 216.1,202.17 216.1,201.92 216.23,201.79 217.09,201.79 217.22,201.67 217.22,201.41 217.09,201.29 216.23,201.29 216.1,201.16 216.1,200.9 216.23,200.78 217.09,200.78 217.22,200.65 217.22,200.4 217.09,200.27 216.23,200.27 216.1,200.14 216.1,195.85 v2(211.45,191.2)
  L08_SIG2 w0.127: v2(211.45,191.2) 210.62,190.36 208.89,190.36 207.14,188.61 207.07,188.61 191.9,173.44 191.9,173.37 179.95,161.42 179.95,150.27 179.64,149.97 179.64,149.8 179.45,149.62 179.45,142.08 179.55,141.98 179.55,141.65 v2(179.78,141.42)
  BOTTOM w0.127: R713.1 180.47,140.73 v2(179.78,141.42)
BUF_MMC1_CMD: length 104
  TOP w0.127: v2(213.36,211.85) 213.51,211.7 U142.18
  L03_SIG1 w0.127: v2(213.36,211.85) 214.99,210.23 214.99,201.89 214.86,201.76 213.56,201.76 213.44,201.63 213.44,201.38 213.56,201.25 214.86,201.25 214.99,201.12 214.99,200.87 214.86,200.74 213.56,200.74 213.44,200.62 213.44,200.36 213.56,200.24 214.86,200.24 214.99,200.11 214.99,199.85 214.86,199.73 213.56,199.73 213.44,199.6 213.44,199.35 213.56,199.22 214.86,199.22 214.99,199.09 214.99,198.84 214.86,198.71 213.56,198.71 213.44,198.58 213.44,198.33 213.56,198.2 214.86,198.2 214.99,198.08 214.99,197.82 214.86,197.7 213.56,197.7 213.44,197.57 213.44,197.31 213.56,197.19 214.86,197.19 214.99,197.06 214.99,195.81 v2(210.36,191.18)
  L08_SIG2 w0.127: v2(179.07,141.8) 179.07,149.77 179.26,149.96 179.26,161.34 209.1,191.18 v2(210.36,191.18)
  BOTTOM w0.127: R714.1 178.94,140.5 178.74,140.71 178.74,141.47 v2(179.07,141.8)
BUF_MMC1_DAT0: length 89.6
  TOP w0.127: U142.17 v2(213.51,211.05)
  L03_SIG1 w0.127: v2(213.51,211.05) 212.46,211.05 211.32,209.91 211.32,196.14 204.39,189.22 204.39,168.37 204.11,168.09 204.11,149.6 201.75,147.23 193.8,147.23 189.59,143.02 188.85,143.02 187.78,141.95 186.99,141.95 v2(186.69,141.65)
  BOTTOM w0.127: RA15.8 185.69,141.15 185.83,141.29 186.33,141.29 v2(186.69,141.65)
BUF_MMC1_DAT1: length 97.3
  TOP w0.127: v2(212.7,209.67) 213.43,210.4 U142.16
  L03_SIG1 w0.127: v2(212.7,209.67) 212.17,209.67 211.73,209.23 211.73,195.44 205.7,189.41 205.7,188.88 205.57,188.75 204.76,188.75 204.64,188.63 204.64,188.37 204.76,188.24 205.57,188.24 205.7,188.12 205.7,187.86 205.57,187.74 204.76,187.74 204.64,187.61 204.64,187.36 204.76,187.23 205.57,187.23 205.7,187.1 205.7,186.85 205.57,186.72 204.76,186.72 204.64,186.59 204.64,186.34 204.76,186.21 205.57,186.21 205.7,186.09 205.7,185.83 205.57,185.7 204.76,185.7 204.64,185.58 204.64,185.32 204.76,185.2 205.57,185.2 205.7,185.07 205.7,183.72 204.9,182.92 204.9,168.09 204.39,167.58 204.39,149.53 201.81,146.95 194.18,146.95 189.15,141.92 188.15,141.92 187.42,141.19 186.26,141.19 v2(185.7,141.75)
  BOTTOM w0.127: v2(185.7,141.75) 185.04,141.09 RA15.7
BUF_MMC1_DAT2: length 96.1
  TOP w0.127: U142.15 v2(213.53,209.75)
  L03_SIG1 w0.127: v2(213.53,209.75) 212.92,209.13 212.34,209.13 212.14,208.93 212.14,194.99 206.43,189.27 206.43,188.72 206.3,188.59 206.07,188.59 205.94,188.46 205.94,188.21 206.07,188.08 206.3,188.08 206.43,187.96 206.43,187.7 206.3,187.57 206.07,187.57 205.94,187.45 205.94,187.19 206.07,187.07 206.3,187.07 206.43,186.94 206.43,186.69 206.3,186.56 206.07,186.56 205.94,186.43 205.94,186.18 206.07,186.05 206.3,186.05 206.43,185.92 206.43,185.67 206.3,185.54 206.07,185.54 205.94,185.42 205.94,185.16 206.07,185.03 206.3,185.03 206.43,184.91 206.43,184.65 206.3,184.53 206.07,184.53 205.94,184.4 205.94,184.15 206.07,184.02 206.3,184.02 206.43,183.89 206.43,183.64 206.3,183.51 206.07,183.51 205.94,183.38 205.94,183.13 206.07,183 206.3,183 206.43,182.88 206.43,181.99 206.3,181.87 205.97,181.87 205.84,181.74 205.84,181.48 205.97,181.36 206.3,181.36 206.43,181.23 206.43,180.46 205.56,179.59 205.56,167.71 204.71,166.85 204.71,148.21 203.17,146.67 194.3,146.67 189.27,141.65 188.27,141.65 187.45,140.83 185.57,140.83 v2(184.71,141.7)
  BOTTOM w0.127: RA15.6 184.53,141.52 v2(184.71,141.7)
BUF_MMC1_DAT3: length 100.4
  TOP w0.127: v2(212.6,208.57) 213.12,209.1 U142.14
  L03_SIG1 w0.127: v2(212.6,208.57) 212.6,207.01 212.72,206.88 214.05,206.88 214.17,206.76 214.17,206.5 214.05,206.37 212.72,206.37 212.6,206.25 212.6,205.99 212.72,205.87 214.05,205.87 214.17,205.74 214.17,205.49 214.05,205.36 212.72,205.36 212.6,205.23 212.6,204.98 212.72,204.85 214.05,204.85 214.17,204.72 214.17,204.47 214.05,204.34 212.72,204.34 212.6,204.22 212.6,194.47 207.11,188.98 207.11,179.54 206.25,178.68 206.25,167.34 205.16,166.25 205.16,148.31 203.21,146.37 194.56,146.37 189.56,141.37 188.44,141.37 187.67,140.59 184.9,140.59 v2(183.79,141.7)
  BOTTOM w0.127: v2(183.79,141.7) 183.88,141.6 RA15.5
BUF_SOC_TDO: length 84.9
  TOP w0.127: v2(195.81,139.38) 194.05,137.62 U59.4 ; v2(225.93,92.22) 226.06,92.09 226.06,91.22 226.31,90.97 U133.4
  L08_SIG2 w0.127: v2(225.93,92.22) 225.55,92.6 220.69,92.6 220.66,92.57 220.28,92.57 220.26,92.6 220.19,92.6 219.37,93.42 219.37,96.01 217.63,97.75 217.63,98.46 217.6,98.49 217.6,112.03 218.62,113.04 222.69,113.04 224.14,114.49 224.14,120.74 208.37,136.51 207.64,136.51 205.97,138.19 197,138.19 v2(195.81,139.38)
BUF_TXVR_RXD: length 38.5
  TOP w0.127: v2(32.26,96.53) 33.35,95.44 U147.4 ; R547.2 v2(25.74,128.08)
  L03_SIG1 w0.127: v2(25.74,128.08) 25.74,113.17 26.94,111.98 26.94,102.11 32.26,96.79 v2(32.26,96.53)
BUF_TXVR_TXD: length 40.3
  TOP w0.127: v2(32.26,95.65) 32.95,94.95 U147.5 ; R542.1 v2(25.74,129.61)
  L03_SIG1 w0.127: v2(32.26,95.65) 32.77,96.15 32.77,96.92 27.18,102.5 27.18,114.8 26.67,115.31 26.67,128.68 v2(25.74,129.61)
BUF_XDS_TCK: length 30.8
  TOP w0.127: U134.2 223.82,110.53 224.36,111.06 224.36,112.18 225.86,113.68 v2(226.95,113.68) ; R323.1 v2(224.8,93.87)
  L08_SIG2 w0.127: v2(226.95,113.68) 226.95,113.6 225.98,112.64 225.98,110.45 226.92,109.51 226.92,108.92 227.03,108.81 227.03,106.51 226.92,106.4 226.92,105.03 223.85,101.96 223.85,99.77 222.84,98.76 222.84,97.01 223.21,96.64 223.71,96.64 224.8,95.55 v2(224.8,93.87)
BUF_XDS_TDI: length 28.9
  TOP w0.127: U134.5 223.53,108.58 224.79,109.84 224.79,111.93 225.86,112.99 229.13,112.99 v2(229.44,113.3) ; U41.20 v2(224.3,97.3)
  L08_SIG2 w0.127: v2(224.3,97.3) 227.91,100.91 227.91,102.98 228.52,103.6 228.52,112.38 v2(229.44,113.3)
BUF_XDS_TMS: length 18.8
  TOP w0.127: v2(226.52,110.58) 226.52,110.1 226.74,109.88 U134.14 ; U41.18 v2(223.3,97.2)
  L08_SIG2 w0.127: v2(226.52,110.58) 227.3,109.79 227.3,109.07 227.41,108.97 227.41,106.35 227.3,106.25 227.3,103.31 224.54,100.54 224.54,98.44 v2(223.3,97.2)
BUF_XDS_TRST#: length 19.4
  TOP w0.127: U41.19 v2(223.8,95.9) ; U134.11 226.45,107.93 226.14,108.24 v2(225.91,108.24)
  L08_SIG2 w0.127: v2(223.8,95.9) 223.44,96.26 223.05,96.26 222.68,96.63 222.46,96.85 222.46,98.92 222.53,98.99 222.53,101.18 225.96,104.6 225.96,108.19 v2(225.91,108.24)
BUFF_DSS_DE: length 68.1
  TOP w0.127: v2(160.86,83.45) 162.56,85.16 R512.1 ; U82.M6 129.25,61.25 v1(128.85,60.85) ; U82.F6 v1(134.45,61.72)
  L03_SIG1 w0.127: v1(134.45,61.72) 134.45,60.25 135.31,59.4 140.16,59.4 141.86,61.1 141.86,70.42 143.28,71.85 153.67,71.85 161.34,79.52 161.34,82.97 v2(160.86,83.45)
  L08_SIG2 w0.102: v1(128.85,60.85) 129.27,61.27 129.27,61.77 129.5,61.99 129.51,61.99 129.93,62.41 129.94,62.41 129.95,62.42 133.75,62.42 v1(134.45,61.72)
BUFF_DSSDATA0: length 77.2
  TOP w0.127: U81.A5 v1(163.85,62.91) ; U81.J5 156.65,62.91 v1(156.65,61.03)
  L03_SIG1 w0.127: v2(176.4,97.04) 176.9,96.55 176.9,96.08 176.51,95.69 176.51,88.91 174.5,86.9 174.5,85.56 174.37,85.44 172.45,85.44 172.33,85.31 172.33,85.05 172.45,84.93 174.37,84.93 174.5,84.8 174.5,84.55 174.37,84.42 172.45,84.42 172.33,84.29 172.33,84.04 172.45,83.91 174.37,83.91 174.5,83.78 174.5,83.53 174.37,83.4 172.45,83.4 172.33,83.28 172.33,83.02 172.45,82.9 174.37,82.9 174.5,82.77 174.5,82.51 174.37,82.39 172.45,82.39 172.33,82.26 172.33,82.01 172.45,81.88 174.37,81.88 174.5,81.75 174.5,81.5 174.37,81.37 172.45,81.37 172.33,81.24 172.33,80.99 172.45,80.86 174.37,80.86 174.5,80.74 174.5,80.02 175.36,79.16 175.36,77.51 170.45,72.6 170.27,72.6 169.65,73.22 169.47,73.22 169.29,73.04 169.29,72.86 169.91,72.24 169.91,72.06 169.73,71.88 169.55,71.88 168.93,72.5 168.75,72.5 168.57,72.32 168.57,72.14 169.2,71.52 169.2,71.34 165,67.14 165,63.97 164.11,63.08 164.08,63.08 163.9,62.91 v1(163.85,62.91)
  BOTTOM w0.127: v1(163.85,62.91) 163.45,62.51 163.45,61.97 163.45,61.96 163.45,61.94 162.14,60.63 157.05,60.63 v1(156.65,61.03) ; v2(176.4,97.04) 176.4,97.72 RA10.8
BUFF_DSSDATA1: length 74.9
  TOP w0.102: 156.65,60.23 156.65,60.02 157.26,59.41 157.34,59.41 ; v1(163.85,62.11) 163.85,62.06 163.68,61.89 163.68,61.87 163.68,61.87 163.68,61.85 162.25,60.42
  TOP w0.127: U81.A6 v1(163.85,62.11) ; 157.34,59.41 157.57,59.18 161.01,59.18 162.25,60.42 ; U81.J6 157.05,60.63 156.65,60.23
  L03_SIG1 w0.127: v2(176.4,96.28) 176.19,96.06 176.19,94.65 176.06,94.53 173.99,94.53 173.86,94.4 173.86,94.15 173.99,94.02 176.06,94.02 176.19,93.89 176.19,93.64 176.06,93.51 173.99,93.51 173.86,93.38 173.86,93.13 173.99,93 176.06,93 176.19,92.88 176.19,92.62 176.06,92.5 173.99,92.5 173.86,92.37 173.86,92.11 173.99,91.99 176.06,91.99 176.19,91.86 176.19,90.31 175.42,89.55 174.88,89.55 174.75,89.42 174.75,87.9 174.62,87.77 174.37,87.77 174.24,87.9 174.24,89.42 174.12,89.55 173.86,89.55 173.74,89.42 173.74,87.9 173.61,87.77 173.35,87.77 173.23,87.9 173.23,89.42 173.1,89.55 172.85,89.55 172.08,88.79 172.08,80.79 171.78,80.48 171.64,80.48 171.07,79.91 171.07,75.8 167.55,72.28 167.55,70.09 164.54,67.08 164.54,63.84 164.02,63.31 163.98,63.31 163.7,63.31 163.46,63.07 163.46,62.69 163.85,62.3 v1(163.85,62.11)
  BOTTOM w0.127: RA10.7 176.91,96.79 v2(176.4,96.28)
BUFF_DSSDATA2: length 74.9
  TOP w0.127: U81.B5 v1(163.05,62.91) ; U81.K5 155.85,62.91 v1(155.85,61.03)
  L03_SIG1 w0.127: v2(178.16,96.31) 176.79,94.94 176.79,84.94 176.66,84.81 174.88,84.81 174.75,84.68 174.75,84.43 174.88,84.3 176.66,84.3 176.79,84.18 176.79,83.92 176.66,83.8 174.88,83.8 174.75,83.67 174.75,83.41 174.88,83.29 176.66,83.29 176.79,83.16 176.79,82.91 176.66,82.78 174.88,82.78 174.75,82.65 174.75,82.4 174.88,82.27 176.66,82.27 176.79,82.14 176.79,81.89 176.66,81.76 174.88,81.76 174.75,81.64 174.75,81.38 174.88,81.26 176.66,81.26 176.79,81.13 176.79,80.87 176.66,80.75 174.88,80.75 174.75,80.62 174.75,80.37 174.88,80.24 176.66,80.24 176.79,80.11 176.79,78.54 165.43,67.18 165.43,63.12 164.02,61.71 163.69,61.71 163.45,61.95 163.45,62.3 163.05,62.69 v1(163.05,62.91)
  BOTTOM w0.127: v1(155.85,61.03) 155.85,61.07 156.03,61.25 156.03,61.28 156.4,61.65 160.49,61.65 160.88,61.25 161.96,61.25 162.65,61.94 162.65,62.5 v1(163.05,62.91) ; v2(178.16,96.31) 177.72,96.31 177.42,96.6 RA10.6
