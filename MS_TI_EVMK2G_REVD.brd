# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPLD_TXD1: length 46.8
  TOP w0.127: v2(240.12,86.11) R126.2 ; U17.F19 248.6,54.45 248.75,54.29 249.4,54.29 v1(249.41,54.29)
  L03_SIG1 w0.102: 250.98,59.1 248.41,56.53 248.41,54.62 248.75,54.29 v1(249.41,54.29)
  L03_SIG1 w0.127: v2(240.12,86.11) 240.12,81.99 244.27,77.84 249.99,77.84 253.95,73.88 253.95,62.85 251.21,60.11 251.21,59.32 250.98,59.1
CPLD_WEN: length 59.6
  TOP w0.102: U9.F9 v2(242.98,72.04) 243.36,72.04
  TOP w0.127: v2(244.88,67.93) 244.47,67.52 242.98,67.52 242.32,66.86 R618.1 ; 243.36,72.04 243.57,72.04 243.99,71.62 243.99,71.13 244.81,70.32 250.37,70.32 251.33,71.29 251.33,74.15 251.19,74.29 251.19,79.5 253.21,81.52 253.21,91.43 252.4,92.24 250.22,92.24 250.06,92.39 250.06,94.07 250.38,94.39 U12.14
  L08_SIG2 w0.127: v2(244.88,67.93) 244.32,67.93 244.12,68.14 244.12,69.45 244.61,69.94 245.29,69.94 245.58,69.64 245.58,69.26 245.46,69.13 244.83,69.13 244.7,69 244.7,68.75 244.83,68.62 245.46,68.62 245.61,68.47 245.61,67.72 245.74,67.59 245.99,67.59 246.12,67.72 246.12,68.96 246.22,69.06 246.71,69.06 246.84,69.19 246.84,69.45 246.71,69.57 246.22,69.57 246.09,69.7 246.09,69.99 246.12,70.02 246.12,70.15 246,70.28 244.44,70.28 244.31,70.41 244.31,70.7 243.83,71.18 243.83,71.36 244.29,71.82 244.29,72 244.11,72.18 243.93,72.18 243.47,71.72 243.29,71.72 v2(242.98,72.04)
  BOTTOM w0.127: v2(244.88,67.93) 244.45,67.5 R617.1
CS2_AD0: length 4.1
  TOP w0.127: v2(202.93,96.39) R478.2 U56.8
  BOTTOM w0.127: R478.2 v2(202.93,96.39)
CS2000_AUX_OUT: length 39.3
  TOP w0.127: U1.F14 v1(178.81,117.81) ; v2(189.18,94.66) 189.2,94.66 189.2,94.63 193.42,94.63 193.81,95.02 U56.4
  BOTTOM w0.102: v1(178.81,117.81) 180.54,116.08 180.54,114.57 180.9,114.21 182.73,114.21 183.31,113.64 183.31,111.71 184.84,110.18 184.84,107.96
  BOTTOM w0.127: 184.84,107.96 184.63,107.75 184.63,107.74 184.53,107.64 184.53,103.01 186.99,100.55 189.53,100.55 190.7,99.38 190.7,96.19 v2(189.18,94.66)
CS2000_CLKIN: length 57
  TOP w0.127: v2(195.05,94.25) 195.32,94.52 U56.5 ; v2(200.98,129.02) R816.1 200.58,130.48 197.29,130.48 197.28,130.47 197.18,130.47 197.17,130.48 195.99,130.48 195.98,130.47 195.55,130.47 195.15,130.06 195.15,130.03 194.44,129.32 194.44,128.5 194.17,128.23 193.78,128.23 193.73,128.28 193.67,128.28 193.34,128.62 R817.1
  BOTTOM w0.127: v2(200.98,129.02) 202.75,130.8 203.66,130.8 203.99,130.47 203.99,120.93 201.96,118.9 201.96,113.71 203.1,112.56 203.1,110.03 197,103.93 197,96.2 v2(195.05,94.25)
CVDD: length 99.5
  TOP w0.102: U32.B4 v1(244.84,176.69)
  TOP w0.203: v2(259.24,150.25) U43.9
  TOP w0.381: C214.1 v2(213.54,148.02) ; C214.1 215.06,147.51 214.58,147.03 v2(213.56,147.03) ; C214.1 215.06,148.58 214.71,148.94 v2(213.56,148.94) ; U1.K9 v1(176.41,121.81) U1.J10 ; C264.1 191.6,108.51 v2(190.63,109.49) ; U1.J14 v1(176.41,118.61) U1.K13 v1(175.61,119.41) U1.L12 v1(174.81,120.21) U1.M11 v1(174.01,121.01) U1.N10 v1(174.01,121.81) U1.M9 ; v2(259.24,150.25) 260.28,149.2 R357.1 v2(263.65,147.08) ; U1.P17 v1(172.41,115.41) U1.R18 ; U1.K11 v1(175.61,121.01) U1.L10 ; U1.P13 U1.R12 v1(171.61,120.21) U1.T11 U1.R10 ; U1.P13 U1.R14 v1(171.61,117.81) U1.T15 v1(170.81,117.01) U1.U16 v1(170.01,116.21) ; U1.P13 v1(173.21,118.61) U1.N14 U1.M15 v1(174.81,117.01) U1.L16 v1(175.61,116.21) U1.K17 ; v2(201.09,135.32) 201.4,135.02 C794.1 ; U1.P9 v1(172.41,121.81) U1.R10 ; U1.R10 U1.T9 v1(171.61,122.61) U1.R8 ; U1.R10 U1.P11 ; C795.1 201.11,133.36 v2(200.93,133.54) ; U1.J16 v1(176.41,117.01) U1.K15 U1.L14 v1(174.81,118.61) U1.M13 U1.N12 v1(173.21,120.21) ; U1.L18 v1(174.81,115.41) U1.M17 U1.N16 v1(173.21,117.01) U1.P15 v1(172.41,117.01) U1.R16 v1(171.61,116.21) U1.T17 v1(170.81,115.41)
  L05_PWR1 w0.508: J40.2 255.65,155.77 ; J40.2 254.58,154.7 ; J40.2 255.65,153.63 ; J40.2 256.72,154.7
  BOTTOM w0.127: 169.61,115.81 168.91,115.81 168.82,115.91 168.8,115.91 ; 169.62,116.61 168.96,116.61
  BOTTOM w0.152: 168.8,115.91 C246.2 168.96,116.61 ; 169.62,116.61 v1(170.01,116.21) 169.61,115.81
  BOTTOM w0.305: C593.2 176.84,116.59 v1(176.41,117.01)
  BOTTOM w0.381: C586.1 187.73,111.97 v1(188.29,111.41) ; v1(187.02,127.41) 187.3,127.13 187.68,127.13 C551.1 ; C228.2 172.68,116.74 v1(172.41,117.01) ; C599.2 190.88,109.74 v2(190.63,109.49) ; C591.2 171.61,119.48 v1(171.61,120.21) ; v1(185.75,124.21) 186.06,123.91 186.08,123.91 186.31,123.67 C556.1 ; C183.1 164.97,135.02 v2(165.1,135.14) ; C537.2 171.3,138.53 171.3,137.7 v2(171.31,137.68) ; v1(171.61,116.21) 171.37,115.98 C195.1 ; C535.2 v1(176.41,121.81) ; C263.1 171.94,121.35 v1(172.41,121.81) ; v1(175.61,116.21) 175.61,115.26 C215.1 ; v1(175.61,121.01) 175.72,121.12 C587.2 ; C611.2 171.54,122.54 v1(171.61,122.61) 171.54,122.69 C620.2 ; C628.1 174.27,115.95 v1(174.81,115.41) ; C188.1 173.38,121.01 v1(174.01,121.01) ; C549.1 186.39,127.02 186.14,127.02 v1(185.75,127.41) ; C562.1 186.13,120.81 185.96,120.81 v1(185.75,121.01) ; v1(173.21,105.6) 172.78,105.18 C237.1 ; v1(187.02,121.01) 187.18,120.86 187.47,120.86 C558.1 ; v2(202.59,134.25) 202.21,134.25 201.97,134.01 C796.1 201.97,132.62 201.9,132.55 v2(201.9,132.48) ; C193.1 174.4,117.43 v1(174.81,117.01) ; C196.1 175.62,119.41 v1(175.61,119.41) ; C248.2 173.95,121.87 v1(174.01,121.81) ; C567.1 C553.1 190.8,104.92 v2(190.78,104.89) ; C618.1 172.76,104.14 172.95,104.33 v1(173.21,104.33) ; v1(170.81,115.41) 171.29,114.94 C200.1 ; v1(173.21,118.61) 173.16,118.66 C194.1 ; v2(171.65,134.46) 171.7,134.51 C181.1 ; v1(244.84,176.69) 244.86,176.67 C451.2 ; C627.1 v1(179.98,105.57) ; C560.1 187.42,123.84 187.4,123.84 v1(187.02,124.21) 186.78,124.46 C590.1 ; v2(200.68,134.84) 200.96,134.56 201.47,134.56 201.93,135.02 C797.1 ; v2(259.24,150.25) 260.6,150.25 260.6,150.26 260.99,150.26 261.37,150.64 C716.2 ; v1(173.21,120.21) 173.84,119.58 C191.1
  vias: v2(260.35,146.57) v2(260.35,145.94) v2(260.6,144.92) v2(261.24,147.33) v2(261.24,146.57) v2(261.24,145.94) v2(261.49,144.92) v2(262.25,147.33) v2(262.25,146.57) v2(262.25,145.94) v2(262.51,144.92) v2(263.14,147.33) v2(263.14,146.57) v2(263.14,145.94) v2(263.4,144.92) v2(264.41,147.33) v2(264.54,146.57) v2(265.3,147.33) v2(265.3,146.57) v2(266.06,147.33) v2(266.06,146.57) v2(266.83,146.95)
CVDD1: length 68.3
  TOP w0.152: U1.M5 v1(174.81,125.01)
  TOP w0.203: U44.9 242.93,149.99
  TOP w0.381: v2(240.79,153.81) 240.54,153.56 240.03,153.56 ; J41.2 240.03,153.56 ; 240.03,153.56 240.03,152.31 242.35,149.99 242.93,149.99 ; 240.03,153.56 239.14,153.56 v2(239.01,153.68) ; R360.1 247.35,148.81 247.01,148.48 v2(247.01,147.21) ; R360.1 v2(248.03,147.21) ; R360.1 248.92,148.81 249.3,148.43 v2(249.3,147.21) ; U1.J12 v1(176.41,120.21) ; U1.N18 v1(173.21,115.41) ; U1.T13 v1(170.81,118.61) ; C172.1 172.72,143.02 ; v2(174.17,139.97) 173.76,140.37 173.13,140.37 172.85,140.09 C182.1 ; U1.N8 v1(173.21,122.61)
  L05_PWR1 w0.508: 240.03,153.89 J41.2 ; J41.2 240.03,156.02 ; J41.2 238.96,154.95 ; J41.2 241.1,154.95
  L08_SIG2 w0.127: 173.85,116.61 174.96,116.61 175.2,116.85 175.2,119.56 175.45,119.81 176,119.81 176,116.05 175.77,115.82 173.62,115.82 173.62,116.38 173.85,116.61 ; 176.8,121.21 176.8,120.61 v1(176.41,120.21) 176.02,120.61 176.02,121.34 176.08,121.41 176.6,121.41 176.8,121.21
  L08_SIG2 w0.305: v1(173.21,115.41) 173.62,115.82 ; 176.02,121.35 175.36,122.01 175.36,122.85 175.08,123.13 174.47,123.13 173.96,122.61 v1(173.21,122.61) ; 176,119.81 v1(176.41,120.21)
  L08_SIG2 w0.508: J41.2 241.1,154.95 ; J41.2 240.03,156.02 ; J41.2 238.96,154.95 ; J41.2 240.03,153.89
  BOTTOM w0.127: 169.19,118.68 169.65,118.22 170.42,118.22 v1(170.81,118.61) 170.41,119.01 169.54,119.01 169.21,118.68 169.19,118.68 ; 169.19,118.68 C216.1 ; C176.1 174.82,128.18 174.81,128.18 174.4,127.78 174.4,125.42 v1(174.81,125.01)
  BOTTOM w0.305: C619.2 v1(176.41,120.21)
  BOTTOM w0.381: v2(247.01,147.21) 247.01,150.24 C719.2 ; C536.2 172.21,142.25 v2(171.7,142.76) ; v2(172.72,142.76) 173.12,142.36 173.12,141.88 C247.1 173.05,142.08 v2(173.74,142.76)
  vias: v2(175.29,141.04) v2(237.36,153.68) v2(237.36,152.8) v2(238.12,154.45) v2(238.12,153.68) v2(238.12,152.8) v2(238.76,154.32) v2(238.76,153.05)
CVDD_EN: length 1.9
  TOP w0.127: R346.2 231.18,157.66 231.38,157.86 R340.2
DAC_VOUT: length 20.7
  TOP w0.127: R486.2 116.57,89.64 116,89.07 111.43,89.07 110.92,89.58 110.92,91.23 110.74,91.4 108.71,91.4 108.12,92 U79.4 v2(108.12,94.66) 108.61,94.66 108.77,94.5 U79.3
  BOTTOM w0.127: C670.1 108.12,91.81 v2(108.12,94.66)
DAT0: length 11.2
  TOP w0.127: v2(178.81,181.18) 178.01,181.98 U29.A3
  BOTTOM w0.127: R688.1 178.81,172.57 178.3,173.08 178.3,176.87 178.81,177.37 v2(178.81,181.18)
DAT1: length 10.8
  TOP w0.127: v2(177.66,178.51) 177.66,178.96 177.51,179.11 U29.A4
  BOTTOM w0.127: R682.1 176.9,172.57 177.66,173.33 v2(177.66,178.51)
DAT2: length 11.2
  TOP w0.127: v2(176.39,179.53) 177.01,180.15 U29.A5
  BOTTOM w0.127: v2(176.39,179.53) 176.32,179.46 176.32,173.79 175.25,172.73 R679.1
DAT3: length 8.1
  TOP w0.127: v2(180.08,181.95) 179.14,182.88 U29.B1 U29.B2
  BOTTOM w0.127: R695.1 180.97,177.12 180.08,178.01 v2(180.08,181.95)
DAT4: length 7.5
  TOP w0.127: U29.B3 U29.A2 179.32,181.56 v2(179.44,181.56)
  BOTTOM w0.127: v2(179.44,181.56) 179.44,177.12 179.19,176.87 R691.1
DAT5: length 12.8
  TOP w0.127: v2(181.22,184.1) 180.99,183.88 U29.D1 U29.D2 U29.C3 U29.B4
  BOTTOM w0.127: v2(181.22,184.1) 181.22,178.52 182.62,177.12 R685.1
DAT6: length 9.3
  TOP w0.127: v1(176.76,183.88) 177.01,183.63 U29.C5 U29.B5
  BOTTOM w0.127: R680.1 175.63,179.79 176.76,180.91 v1(176.76,183.88)
DAT7: length 8.8
  TOP w0.127: U29.B6 U29.B7 U29.B8 U29.B9 U29.A9 175.01,180.79 v2(175.25,180.55)
  BOTTOM w0.127: v2(175.25,180.55) 174.11,179.41 R673.1
DBG_EMU0: length 49.8
  TOP w0.127: U17.J16 v1(246.22,52.45)
  L03_SIG1 w0.102: 250.77,54.19 249.1,52.52 247.95,52.52 247.62,52.85 246.62,52.85 v1(246.22,52.45)
  L03_SIG1 w0.127: 250.77,54.19 252.87,56.29 253.71,56.29 256.51,59.1 257.86,59.1 259.36,60.59 259.36,62.65 262.8,66.09 262.8,69.19 261.75,70.25 261.75,77.54 263.93,79.72 264.9,79.72 v2(266.14,80.96)
  BOTTOM w0.127: v1(246.22,52.45) 246.62,52.85 249.61,52.85 250.16,53.41 R636.1 ; v2(266.14,80.96) 266.72,80.39 266.72,80 267.21,79.51 R240.1
DBG_EMU1: length 40.6
  TOP w0.127: U17.K16 v1(246.22,51.65)
  L03_SIG1 w0.102: v1(246.22,51.65) 246.6,52.03 249.27,52.03 250.93,53.69
  L03_SIG1 w0.127: v2(267.23,75.3) 266.14,74.21 263.37,74.21 263.35,74.18 262.99,74.18 262.25,73.45 262.25,70.25 263.26,69.24 263.26,66.04 259.71,62.5 259.71,60.54 257.86,58.69 256.67,58.69 253.94,55.96 253.2,55.96 250.93,53.69
  BOTTOM w0.127: v2(267.23,75.3) R243.1 R641.1
DBG_RTCK: length 28.3
  TOP w0.127: R141.1 v2(264.99,50.61) ; J8.9 v2(268.48,71.16)
  L08_SIG2 w0.127: v2(268.48,71.16) 271.11,68.53 271.11,55.2 266.52,50.61 v2(264.99,50.61)
DBG_SRST: length 34.4
  TOP w0.127: R156.1 v2(261.47,47.56) ; J8.15 v2(272.29,71.21)
  L08_SIG2 w0.127: v2(272.29,71.21) 271.73,71.77 268.39,71.77 267.92,71.3 267.92,55.59 262.79,50.46 262.79,48.88 v2(261.47,47.56)
DBG_TCK: length 51.8
  TOP w0.127: v2(261.62,49.11) 261.65,49.09 R149.2 ; U17.J15 v1(245.42,52.45) ; J8.11 269.67,73.38 v2(269.67,75.28)
  L08_SIG2 w0.102: v1(245.42,52.45) 245.8,52.07 245.8,51.39 245.95,51.25 246.1,51.25
  L08_SIG2 w0.127: v2(269.67,75.28) 266.52,72.13 266.52,54.75 262.23,50.46 262.23,49.72 v2(261.62,49.11) 260.17,50.56 258.01,50.56 257.12,51.45 254.33,51.45 253.59,52.19 249.48,52.19 248.54,51.25 246.1,51.25
DBG_TDI: length 42.8
  TOP w0.127: J8.3 264.67,71.29 v2(264.69,71.26) ; U17.M16 v1(246.22,49.25)
  L03_SIG1 w0.102: 250.98,50.69 248.92,50.69 247.86,49.63 246.6,49.63 v1(246.22,49.25)
  L03_SIG1 w0.127: v2(264.69,71.26) 265.53,72.1 268.81,72.1 269.24,71.67 269.24,70.25 265.18,66.18 265.18,63.77 256.77,55.36 255.53,55.36 253.11,52.95 253.11,52.01 251.79,50.69 250.98,50.69
DBG_TDO: length 32.6
  TOP w0.127: 267.21,73.31 v2(267.21,70.73) ; U17.J18 v1(247.82,51.65)
  L03_SIG1 w0.102: v1(247.82,51.65) 249.5,51.65 250.88,53.02
  L03_SIG1 w0.127: 250.88,53.02 252.4,53.02 255.33,55.96 256.15,55.96 260.22,60.04 260.22,62.1 263.83,65.71 263.83,67.35 v2(267.21,70.73)
DBG_TMS: length 40.7
  TOP w0.127: U17.L16 v1(246.22,50.05) ; J8.1 v2(263.4,71.24)
  L03_SIG1 w0.102: v1(246.22,50.05) 246.6,50.43 247.77,50.43 248.31,50.97 249.43,50.97 250.62,52.16
  L03_SIG1 w0.127: v2(263.4,71.24) 264.11,70.53 265.48,70.53 266.57,71.62 267.36,71.62 267.77,71.21 267.77,69.41 264.16,65.8 264.16,63.39 256.44,55.67 255.44,55.67 252.52,52.75 252.5,52.75 251.92,52.16 250.62,52.16
DBG_TRSTN: length 68.1
  TOP w0.127: J8.2 263.4,80.71 v2(263.3,80.81) ; U17.L17 v1(247.02,50.05) ; R782.1 v2(256.93,48.71)
  L08_SIG2 w0.102: 249.78,49.57 249.28,49.57 248.8,50.05 v1(247.02,50.05)
  L08_SIG2 w0.127: v2(263.3,80.81) 265.63,78.48 271.86,78.48 274.07,76.27 274.07,57.34 265.13,48.4 264.95,48.4 263.32,46.78 259.82,46.78 257.89,48.71 v2(256.93,48.71) 251.66,48.71 250.8,49.57 249.78,49.57
DC_BRD_DET: length 436.4
  TOP w0.127: v2(283.8,56.89) 283.31,57.39 283.31,58.84 283.49,59.02 284.81,59.02 284.95,58.88 285.39,58.88 285.39,59.83 285.57,60.01 R806.2 286.65,60.55 287.16,60.05 R875.2 ; v2(283.8,56.89) 283.8,56.41 283.97,56.24 U69.14 ; v2(283.8,56.89) U69.15 ; v2(65.66,195.54) R192.2 ; v2(211.18,88.25) 208.1,85.18 190.75,85.18 181.18,75.61 134.32,75.61 132.72,77.21 v2(132.72,90.06)
  L03_SIG1 w0.127: v2(283.8,56.89) 283.8,55.14 283.29,54.62 283.29,52.42 295.24,40.46 295.24,35.92 297.97,33.19 300.74,33.19 301.28,32.64 301.28,30.62 JP1.92 ; v2(61.21,186.07) 62.23,186.07 65.66,189.5 v2(65.66,195.54) ; v2(132.72,90.06) 132.27,90.06 131.64,90.69 113.41,90.69 107.21,96.89 82.73,96.89 59.97,119.65 v2(53.59,119.65)
  L08_SIG2 w0.127: v2(61.21,186.07) 61.21,185.35 58.33,182.46 54.18,182.46 52.6,180.89 52.6,163.2 54.15,161.65 54.15,120.21 v2(53.59,119.65)
  BOTTOM w0.127: v2(283.8,56.89) 284.25,56.89 284.41,56.73 286.72,56.73 287.65,57.67 287.65,62.52 277.62,72.56 277.62,77.84 259.91,95.56 259.91,95.58 255.52,99.96 252.6,99.96 249.98,97.34 235.88,97.34 233.81,95.26 225.55,95.26 224.41,96.41 221.23,96.41 220.85,96.03 219.33,96.03 218.31,95.01 218.31,93.61 217.04,92.34 217.04,91.79 213.51,88.25 v2(211.18,88.25) ; R195.2 v2(65.66,195.54)
DC_BRD_DET_INV: length 22.1
  TOP w0.127: U115.22 292.04,53.61 291.35,53.61 291.31,53.64 290.93,53.64 290.9,53.61 289.79,53.61 288.75,54.65 288.75,56.73 289.48,57.47 289.48,61.66 288.57,62.58 280.42,62.58 279.91,62.07 U84.4
DDR_A0: length 135.7
  TOP w0.102: v2(128.02,184.55) R279.1 ; v1(134.51,148.78) 134.61,148.78 134.81,148.98 135.06,148.98 135.15,149.07 135.15,149.07 U45.K3 ; v1(134.51,164.02) 134.61,164.02 134.81,164.22 135.06,164.22 135.65,164.81 U39.K3 ; U52.K3 135.23,118.68 135.23,118.68 135.06,118.5 134.81,118.5 134.61,118.3 v1(134.51,118.3) ; v1(134.51,179.26) 134.61,179.26 134.81,179.46 135.06,179.46 135.65,180.05 U27.K3 ; U49.K3 135.23,133.92 135.23,133.92 135.06,133.74 134.81,133.74 134.61,133.54 v1(134.51,133.54) ; U1.AC15 v1(165.21,117.01)
  L08_SIG2 w0.102: v2(128.02,184.55) 131.32,181.24 131.83,181.24 132.83,180.24 133.53,180.24 v1(134.51,179.26) 134.2,178.96 134.2,176.14 134.01,175.95 134.01,170.27 134.39,169.89 134.39,168.4 134.32,168.32 133.88,168.32 133.78,168.22 133.78,167.92 133.88,167.81 134.32,167.81 134.42,167.71 134.42,167.3 134.43,167.29 134.43,165.97 133.98,165.52 133.98,164.54 v1(134.51,164.02) 134.04,163.55 134.04,155.56 134.11,155.49 134.64,155.49 134.74,155.38 134.74,155.08 134.64,154.98 134.11,154.98 134.01,154.88 134.01,153.26 134.44,152.83 134.44,151.09 134.83,150.71 134.83,149.1 v1(134.51,148.78) 134.22,148.49 134.22,145.72 133.94,145.43 133.94,140.79 134.04,140.69 134.37,140.69 134.47,140.59 134.47,140.28 134.37,140.18 134.04,140.18 133.94,140.08 133.94,137.45 134.8,136.59 134.8,134.92 134.83,134.89 134.83,134.58 134.51,134.26 v1(134.51,133.54) 134.22,133.25 134.22,130.59 133.94,130.31 133.94,129.21 134.04,129.11 134.21,129.11 134.32,129 134.32,128.7 134.21,128.6 134.04,128.6 133.94,128.5 133.94,126.28 133.6,125.95 133.6,124.22 133.71,124.11 133.88,124.11 133.98,124.01 133.98,123.81 133.88,123.71 133.71,123.71 133.6,123.61 133.6,119.2 v1(134.51,118.3) 134.22,118.01 134.22,117.78 134.32,117.68 134.9,117.68 135,117.58 135,117.38 134.9,117.28 134.32,117.28 134.22,117.18 134.22,115.86 135.35,114.73 136.12,114.73 136.91,115.51 137.85,115.51 138.15,115.2 138.15,115.15 138.25,115.05 138.48,115.05 138.58,114.95 138.58,114.53 138.48,114.43 138.13,114.43 138.02,114.32 138.02,114.12 138.13,114.02 138.48,114.02 138.58,113.92 138.58,113.65 138.68,113.55 138.89,113.55 138.99,113.65 138.99,114.11 139.09,114.21 139.34,114.21 139.45,114.31 139.45,114.52 139.34,114.62 139.09,114.62 138.99,114.72 138.99,114.95 139.09,115.05 139.9,115.05 140,114.95 140,114.5 140.11,114.4 140.38,114.4 140.48,114.3 140.48,114.09 140.38,113.99 140.11,113.99 140,113.89 140,112.84 140.23,112.61 140.58,112.61 140.68,112.71 140.68,113.42 140.77,113.5 141.01,113.5 141.09,113.42 141.09,112.71 141.19,112.61 141.4,112.61 141.5,112.71 141.5,113.52 141.6,113.62 141.8,113.62 141.9,113.52 141.9,112.71 142.01,112.61 144.27,112.61 144.42,112.77 145.9,112.77 145.95,112.82 147.47,112.82 150.11,115.46 155.45,115.46 155.91,115.92 157.92,115.92 157.97,115.86 157.99,115.86 158.2,115.65 159.48,115.65 159.74,115.92 160.96,115.92 161.06,115.81 161.8,115.81 162.58,115.03 162.94,115.03 162.96,115.05 162.97,115.05 163.12,115.2 163.12,116.18 163.88,116.94 164.55,116.94 164.62,117.01 v1(165.21,117.01)
DDR_A1: length 135
  TOP w0.102: v1(133.15,116.68) 134.06,116.68 U52.L7 ; U27.L7 134.06,177.64 v1(133.15,177.64) 132.44,177.64 132.38,177.69 130.52,177.69 128.23,175.4 R295.1 ; U45.L7 134.06,147.16 v1(133.15,147.16) ; U1.Y15 v1(167.61,117.01) ; U49.L7 134.06,131.92 v1(133.15,131.92) ; v1(133.15,162.4) 134.06,162.4 U39.L7
  L08_SIG2 w0.102: v1(167.61,117.01) 167.2,116.61 164.86,116.61 164.71,116.46 163.81,116.46 163.37,116.02 163.37,115.15 163.04,114.82 162.5,114.82 162.3,115.03 158.51,115.03 158.3,115.23 158.03,115.23 157.8,115.46 156.52,115.46 156.29,115.23 156.29,115.23 156.01,114.95 155.45,114.95 154.58,114.09 154.58,114.08 154.42,113.91 154.41,113.91 154.15,113.65 153.91,113.65 153.78,113.78 153.78,114.49 153.68,114.59 153.47,114.59 153.37,114.49 153.37,113.73 153.3,113.65 153.07,113.65 152.97,113.76 152.97,114.75 152.86,114.85 152.66,114.85 152.56,114.75 152.56,113.76 152.46,113.65 152.26,113.65 152.15,113.76 152.15,114.75 152.05,114.85 151.85,114.85 151.75,114.75 151.75,113.76 151.65,113.65 151.44,113.65 151.34,113.76 151.34,114.75 151.24,114.85 151.04,114.85 150.93,114.75 150.93,113.76 150.83,113.65 150.63,113.65 150.53,113.76 150.53,114.75 150.43,114.85 150.22,114.85 150.12,114.75 150.12,113.76 150.02,113.65 149.71,113.65 148.46,112.41 146.13,112.41 146.08,112.36 138.73,112.36 136.66,114.44 135.25,114.44 133.43,116.25 133.43,116.39 v1(133.15,116.68) 133.71,117.24 133.71,118.4 133.32,118.79 133.32,121.71 132.97,122.06 132.97,126.86 133.07,126.96 133.27,126.96 133.38,127.06 133.38,127.37 133.27,127.47 133.07,127.47 132.97,127.57 132.97,127.95 133.46,128.45 133.46,129.07 133.43,129.11 133.43,130.11 133.15,130.39 v1(133.15,131.92) 133.15,132.5 132.87,132.78 132.87,133.72 133.05,133.9 133.05,137.75 132.59,138.2 132.59,142.9 132.69,143.01 133.05,143.01 133.15,143.11 133.15,143.41 133.05,143.51 132.69,143.51 132.59,143.62 132.59,144.38 133.15,144.94 v1(133.15,147.16) 133.15,147.82 132.89,148.08 132.89,150.38 133.17,150.66 133.17,152.45 132.57,153.05 132.57,153.57 132.68,153.67 132.84,153.67 132.94,153.77 132.94,154.08 132.84,154.18 132.68,154.18 132.57,154.28 132.57,154.59 132.68,154.69 132.84,154.69 132.94,154.79 132.94,155.09 132.84,155.2 132.68,155.2 132.57,155.3 132.57,159.61 132.96,159.99 132.96,161.3 133.15,161.49 v1(133.15,162.4) 133.15,163.01 132.89,163.26 132.89,164.07 132.99,164.18 132.99,166.01 133,166.01 133,166.33 132.99,166.33 132.99,168.32 132.59,168.72 132.59,173.49 132.69,173.59 133.25,173.59 133.35,173.7 133.35,174 133.25,174.1 132.69,174.1 132.59,174.2 132.59,174.86 133.15,175.42 v1(133.15,177.64)
DDR_A2: length 136
  TOP w0.102: v1(133.29,133.24) 133.44,133.24 134.21,134.01 134.53,134.01 U49.L3 ; R285.1 127.7,176.93 128.21,177.44 128.21,178.18 129.26,179.23 131.39,179.23 131.56,179.06 133.18,179.06 v1(133.29,178.96) 133.44,178.96 134.15,179.67 134.47,179.67 U27.L3 ; U39.L3 134.47,164.43 134.15,164.43 133.5,163.77 v1(133.29,163.77) ; U1.AC16 v1(165.21,116.21) ; U52.L3 134.53,118.77 134.21,118.77 133.44,118 v1(133.29,118) ; v1(133.29,148.4) 133.36,148.4 134.15,149.19 134.47,149.19 U45.L3
  L03_SIG1 w0.102: v1(165.21,116.21) 164.8,116.21 163.28,114.7 162.69,114.7 162.2,114.21 160.71,114.21 160.15,113.65 158.36,113.65 158,113.29 157.64,113.29 157.61,113.32 153.96,113.32 153.93,113.29 153.18,113.29 152.7,113.77 151.9,113.77 150.62,112.49 148.95,112.49 148.35,111.89 147.81,111.89 147.73,111.97 147.73,113.02 147.63,113.12 147.43,113.12 147.33,113.02 147.33,112.09 147.2,111.97 147,111.97 146.9,112.07 146.9,113.1 146.79,113.2 146.59,113.2 146.49,113.1 146.49,111.99 146.39,111.89 146.19,111.89 146.08,111.99 146.08,113.1 145.98,113.2 145.78,113.2 145.68,113.1 145.68,111.99 145.58,111.89 144.77,111.89 143.1,110.23 134.32,110.23 132.98,111.56 132.98,112.5 132.66,112.82 132.66,113.93 133.22,114.49 133.22,116.07 133.57,116.42 133.57,117.71 v1(133.29,118) 133.29,122.05 132.87,122.47 132.87,126.2 132.97,126.3 133.1,126.3 133.2,126.4 133.2,126.68 133.1,126.78 132.97,126.78 132.87,126.89 132.87,127.95 133.5,128.59 133.5,129.21 133.25,129.47 133.25,130.97 133.81,131.53 133.81,132.72 v1(133.29,133.24) 133.29,137.01 133.18,137.12 132.92,137.12 132.82,137.22 132.82,137.52 132.92,137.62 133.18,137.62 133.29,137.72 133.29,140.58 133.39,140.69 133.45,140.69 133.55,140.79 133.55,140.99 133.45,141.09 133.39,141.09 133.29,141.19 133.29,143.45 133.5,143.67 133.5,145.03 133.26,145.27 133.26,146.13 133.27,146.14 133.27,146.17 133.78,146.67 133.78,147.91 v1(133.29,148.4) 133.29,148.81 133.5,149.02 133.5,150.54 133.6,150.64 134.11,150.64 134.21,150.74 134.21,151.05 134.11,151.15 133.6,151.15 133.5,151.25 133.5,158.34 133.55,158.39 133.55,160.22 133.25,160.53 133.25,161.53 133.6,161.89 133.6,163.46 v1(133.29,163.77) 133.29,164.18 133.45,164.35 133.45,165.9 133.55,166 133.93,166 134.04,166.1 134.04,166.41 133.93,166.51 133.55,166.51 133.45,166.61 133.45,167.39 133.35,167.5 133.1,167.5 132.99,167.6 132.99,167.9 133.1,168 133.35,168 133.45,168.11 133.45,174.47 133.46,174.48 133.46,174.79 133.45,174.81 133.45,175.57 133.25,175.77 133.25,177 133.57,177.33 133.57,178.67 v1(133.29,178.96)
DDR_A3: length 128.4
  TOP w0.102: U45.K2 135.25,150.77 v1(135.25,150.77) ; v1(135.25,135.53) 135.25,135.53 U49.K2 ; R256.1 132.59,185.94 135.25,183.28 v1(135.25,181.25) 135.25,181.24 135.64,180.85 U27.K2 ; v1(135.25,120.29) 135.25,120.29 U52.K2 ; U1.AA15 v1(166.81,117.01) ; v1(135.25,166.01) 135.25,166 135.64,165.61 U39.K2
  L03_SIG1 w0.102: v1(166.81,117.01) 166.41,117.41 165.02,117.41 164.74,117.13 164.74,116.88 163.7,115.83 160.81,115.83 160.45,116.19 159.67,116.19 159.04,115.57 149.65,115.57 147.7,117.52 145.21,117.52 143.92,116.22 143.92,113.76 142.3,112.14 137.78,112.14 137.63,112.28 137.25,112.28 137.23,112.26 136.89,112.26 136.86,112.28 136.21,112.28 136.11,112.38 135.97,112.38 135.63,112.72 135.63,112.87 135.73,112.97 135.73,113.11 135.58,113.26 135.44,113.26 135.34,113.15 135.2,113.15 134.87,113.48 134.87,114.4 134.98,114.51 135.2,114.51 135.31,114.4 135.31,114.16 135.36,114.11 135.66,114.11 135.71,114.16 135.71,114.4 135.81,114.51 136.04,114.51 136.14,114.61 136.14,114.81 136.04,114.91 134.98,114.91 134.67,115.22 134.67,115.64 135.25,116.21 135.25,117.18 135.35,117.28 135.59,117.28 135.69,117.38 135.69,117.59 135.59,117.69 135.35,117.69 135.25,117.79 135.25,117.99 135.35,118.1 135.59,118.1 135.69,118.2 135.69,118.4 135.59,118.5 135.35,118.5 135.25,118.6 135.25,118.81 135.35,118.91 135.59,118.91 135.69,119.01 135.69,119.21 135.59,119.31 135.35,119.31 135.25,119.42 v1(135.25,120.29) 136.03,121.08 136.03,121.46 136.02,121.47 136.02,125.03 135.92,125.13 135.82,125.13 135.72,125.23 135.72,125.54 135.82,125.64 135.92,125.64 136.02,125.74 136.02,126.21 135.76,126.46 135.76,128.31 136.2,128.74 136.2,129.78 135.64,130.34 135.64,131.03 135.25,131.42 v1(135.25,135.53)
  L08_SIG2 w0.102: v1(135.25,181.25) 135.25,177.25 134.86,176.86 134.86,175.89 134.98,175.78 135.43,175.78 135.53,175.68 135.53,175.37 135.43,175.27 134.98,175.27 134.87,175.17 134.87,174.71 135.48,174.1 135.48,167.57 135.25,167.33 v1(135.25,166.01) 135.25,165.58 135.01,165.35 135.01,163.81 134.42,163.21 134.42,161.18 135.25,160.35 135.25,156.87 135.15,156.77 134.62,156.77 134.52,156.67 134.52,156.36 134.62,156.26 135.15,156.26 135.25,156.16 v1(135.25,150.77) 135.25,146.7 134.86,146.32 134.86,145.82 134.87,145.81 134.87,144.13 135.38,143.63 135.38,141.95 135.28,141.85 134.77,141.85 134.67,141.75 134.67,141.44 134.77,141.34 135.28,141.34 135.38,141.24 135.38,136.99 135.25,136.85 v1(135.25,135.53)
DDR_A4: length 137.5
  TOP w0.102: U27.L8 134.82,176.05 134.43,176.44 133.65,176.44 v1(133.64,176.45) ; v1(133.64,145.97) 133.65,145.96 134.43,145.96 134.82,145.57 U45.L8 ; U39.L8 134.82,160.81 134.43,161.2 133.65,161.2 v1(133.64,161.21) ; R261.1 v2(127.89,167.78) ; U49.L8 134.82,130.33 134.43,130.72 133.65,130.72 v1(133.64,130.73) ; U1.AB16 v1(166.01,116.21) ; U52.L8 134.45,115.49 v1(133.64,115.49)
  L03_SIG1 w0.102: v1(166.01,116.21) 165.62,116.6 164.85,116.6 163.28,115.03 161.41,115.03 161.38,115.01 160.83,115.01 160.07,114.25 158.54,114.25 158.24,114.54 151.99,114.54 151.3,113.85 150.43,113.85 150.33,113.74 150.33,113.02 150.22,112.92 150.02,112.92 149.92,113.02 149.92,113.74 149.82,113.85 149.59,113.85 149.49,113.74 149.49,112.99 149.39,112.89 149.18,112.89 149.08,112.99 149.08,113.74 148.98,113.85 148.75,113.85 148.65,113.74 148.65,112.89 148.55,112.79 148.34,112.79 148.24,112.89 148.24,113.74 148.14,113.85 145.48,113.85 144.89,113.26 144.89,113.12 145.17,112.84 145.17,112.7 145.03,112.55 144.88,112.55 144.61,112.83 144.46,112.83 143.75,112.11 143.75,111.97 143.87,111.85 143.87,111.71 143.72,111.56 143.58,111.56 143.46,111.68 143.31,111.68 143.17,111.54 143.17,111.39 143.29,111.27 143.29,111.13 143.15,110.99 143,110.99 142.88,111.11 142.74,111.11 142.52,110.89 141.88,110.89 141.78,110.78 141.78,110.73 141.68,110.63 141.48,110.63 141.38,110.73 141.38,110.78 141.27,110.89 141.07,110.89 140.97,110.78 140.97,110.73 140.87,110.63 140.66,110.63 140.56,110.73 140.56,110.78 140.46,110.89 140.23,110.89 140.13,110.78 140.13,110.73 140.03,110.63 139.83,110.63 139.72,110.73 139.72,110.78 139.62,110.89 139.42,110.89 139.32,110.78 139.32,110.73 139.22,110.63 139.01,110.63 138.91,110.73 138.91,110.78 138.81,110.89 138.61,110.89 138.51,110.78 138.51,110.73 138.4,110.63 138.2,110.63 138.1,110.73 138.1,110.78 138,110.89 137.79,110.89 137.69,110.78 137.69,110.73 137.59,110.63 137.39,110.63 137.29,110.73 137.29,110.78 137.18,110.89 136.98,110.89 136.88,110.78 136.88,110.73 136.78,110.63 136.58,110.63 136.47,110.73 136.47,110.78 136.37,110.89 136.17,110.89 136.07,110.78 136.07,110.73 135.97,110.63 135.76,110.63 135.66,110.73 135.66,110.78 135.56,110.89 135.08,110.89 134.98,110.99 134.98,111.12 134.88,111.22 134.68,111.22 134.58,111.12 134.58,110.99 134.47,110.89 134.23,110.89 133.64,111.47 133.64,111.84 133.75,111.94 134.09,111.94 134.19,112.04 134.19,112.24 134.09,112.34 133.75,112.34 133.64,112.45 v1(133.64,115.49) 133.64,115.92 133.81,116.09 133.81,120.36 133.6,120.56 133.6,122.04 133.81,122.24 133.81,124.24 133.71,124.34 133.48,124.34 133.38,124.44 133.38,124.75 133.48,124.85 133.71,124.85 133.81,124.95 133.81,125.24 133.71,125.34 133.48,125.34 133.38,125.44 133.38,125.72 133.48,125.82 133.71,125.82 133.81,125.92 133.81,129.35 133.64,129.51 v1(133.64,130.73)
  L08_SIG2 w0.102: v1(133.64,130.73) 133.64,132.29 133.72,132.36 133.72,133.53 133.43,133.82 133.43,135.04 133.55,135.16 134.08,135.16 134.18,135.26 134.18,135.47 134.08,135.57 133.51,135.57 133.43,135.65 133.43,143.78 133.64,144 v1(133.64,145.97) 133.64,146.38 133.78,146.52 133.78,149.14 133.68,149.25 133.47,149.25 133.4,149.31 133.4,149.69 133.47,149.75 133.68,149.75 133.78,149.86 133.78,150.31 133.49,150.6 133.49,156.03 133.39,156.13 133.18,156.13 133.08,156.23 133.08,156.53 133.18,156.64 133.39,156.64 133.49,156.74 133.49,157.04 133.39,157.14 133.18,157.14 133.08,157.25 133.08,157.55 133.18,157.65 133.39,157.65 133.49,157.75 133.49,158.26 133.64,158.41 v1(133.64,161.21) 133.64,163.41 133.68,163.45 133.68,164.1 133.37,164.4 133.37,165.9 133.48,166 133.96,166 134.06,166.1 134.06,166.41 133.96,166.51 133.48,166.51 133.37,166.61 133.37,169.62 133.27,169.72 133.1,169.72 132.99,169.82 132.99,170.03 133.1,170.13 133.27,170.13 133.37,170.23 133.37,173.17 133.64,173.44 v1(133.64,176.45)
  BOTTOM w0.102: v1(133.64,176.45) 132.65,175.46 132.65,172.52 128.03,167.9 127.89,167.9 v2(127.89,167.78)
DDR_A5: length 130.7
  TOP w0.102: v1(134.45,180.46) 134.52,180.53 134.52,180.55 134.81,180.85 U27.L2 ; v1(134.45,149.98) 134.52,150.05 134.52,150.07 134.81,150.37 U45.L2 ; U49.L2 134.84,135.13 v1(134.45,134.74) ; U39.L2 134.81,165.61 134.52,165.31 134.52,165.29 v1(134.45,165.22) ; v1(134.45,119.5) 134.84,119.89 U52.L2 ; R230.1 v2(128.27,183.02)
  TOP w0.127: U1.AE17 161.87,115.81 v1(161.47,115.41)
  L03_SIG1 w0.102: v2(128.27,183.02) 129.41,181.88 133.02,181.88 v1(134.45,180.46) 134.09,180.1 134.09,175.83 134.07,175.81 134.07,175.5 134.09,175.48 134.09,170 134.18,169.91 134.52,169.91 134.62,169.81 134.62,169.5 134.52,169.4 134.18,169.4 134.08,169.3 134.08,169 134.18,168.89 134.52,168.89 134.62,168.79 134.62,168.49 134.52,168.39 134.18,168.39 134.08,168.28 134.08,167.88 134.45,167.51 v1(134.45,165.22) 134.01,165.22 133.83,165.04 133.83,163.75 134.11,163.46 134.47,163.46 134.57,163.36 134.57,163.06 134.47,162.96 134.11,162.96 134.01,162.85 134.01,161.38 134.03,161.37 134.03,161.05 134.01,161.04 134.01,153.1 134.45,152.67 v1(134.45,149.98) 134.09,149.62 134.09,145.35 134.07,145.33 134.07,138.74 134.18,138.62 134.62,138.62 134.72,138.52 134.72,138.22 134.62,138.12 134.18,138.12 134.08,138.01 134.08,137.4 133.63,136.95 133.63,135.9 134.45,135.08 v1(134.45,134.74) 134.06,134.35 134.06,127.95 134.42,127.6 134.6,127.6 134.7,127.5 134.7,127.16 134.6,127.06 134.42,127.06 134.32,126.96 134.32,126.65 134.42,126.55 134.6,126.55 134.7,126.45 134.7,126.15 134.6,126.04 134.42,126.04 134.32,125.94 134.32,121.81 134.45,121.68 v1(134.45,119.5) 134.08,119.13 134.08,117.88 134.18,117.78 134.58,117.78 134.68,117.68 134.68,117.47 134.58,117.37 134.18,117.37 134.11,117.3 134.11,114.9 134.07,114.85 134.07,112.84 134.61,112.29 135.63,112.29 136.04,111.88 137.47,111.88 137.78,111.56 142.46,111.56 144.45,113.55 144.45,115.53 144.58,115.66 144.75,115.66 144.93,115.48 144.93,114.37 144.98,114.31 145.31,114.31 145.46,114.46 145.46,115.92 145.53,115.99 145.74,115.99 145.84,115.89 145.84,114.54 146.02,114.37 146.26,114.37 146.36,114.47 146.36,116.04 146.46,116.14 146.67,116.14 146.77,116.04 146.77,115.7 146.87,115.6 147.66,115.6 147.76,115.5 147.76,115.29 147.66,115.19 146.87,115.19 146.77,115.09 146.77,114.47 146.87,114.37 147.73,114.37 148.8,115.44 149.06,115.44 149.45,115.05 159.84,115.05 160.2,115.41 v1(161.47,115.41)
DDR_A6: length 136.8
  TOP w0.102: v1(132.7,114.59) 132.75,114.65 133.1,114.65 133.6,114.65 133.73,114.77 133.73,114.77 U52.M8 ; U49.M8 133.73,130.01 133.73,130.01 133.68,129.96 132.95,129.96 v1(132.54,129.55) ; U39.M8 134.05,160.81 133.68,160.44 132.96,160.44 v1(132.07,159.55) ; U1.AC14 v1(165.21,117.81) ; R233.1 128.65,169.31 131.19,171.85 131.19,173.91 v1(132.07,174.79) 132.96,175.68 133.68,175.68 134.05,176.05 U27.M8 ; U45.M8 134.05,145.57 133.68,145.2 132.96,145.2 v1(132.07,144.31)
  L08_SIG2 w0.102: v1(132.7,114.59) 132.7,116.24 132.05,116.89 132.05,117.17 132.16,117.28 132.33,117.28 132.44,117.38 132.44,117.68 132.33,117.78 132.16,117.78 132.05,117.88 132.05,118.73 133.05,119.73 133.05,121.6 132.44,122.21 132.44,129.04 132.54,129.15 v1(132.54,129.55) 132.54,129.96 132.66,130.08 132.66,131.64 132.07,132.24 132.07,134.53 132.17,134.63 132.72,134.63 132.82,134.73 132.82,135.03 132.72,135.14 132.17,135.14 132.07,135.24 v1(132.07,144.31) 132.77,145.01 132.77,147.26 132.07,147.96 132.07,155.72 131.97,155.82 131.75,155.82 131.65,155.92 131.65,156.22 131.75,156.33 131.97,156.33 132.07,156.43 132.07,156.73 131.97,156.83 131.75,156.83 131.65,156.93 131.65,157.24 131.75,157.34 131.97,157.34 132.07,157.44 v1(132.07,159.55) 132.64,160.12 132.64,162.96 132.07,163.53 132.07,164.86 132.17,164.96 132.64,164.96 132.74,165.06 132.74,165.36 132.64,165.46 132.17,165.46 132.07,165.57 v1(132.07,174.79)
  BOTTOM w0.102: v1(132.7,114.59) 132.32,114.98 131.17,114.98 130.78,115.36 130.78,117.31 130.91,117.44 131.14,117.44 131.27,117.31 131.27,116.91 131.37,116.8 131.57,116.8 131.67,116.91 131.67,117.36 131.75,117.44 133.63,117.44 133.73,117.34 133.73,116.02 133.83,115.92 134.13,115.92 134.24,116.02 134.24,117.34 134.34,117.44 136.32,117.44 137.87,115.89 141.17,115.89 141.63,115.43 143.71,115.43 143.81,115.33 143.81,115.1 143.91,115 144.12,115 144.22,115.1 144.22,115.33 144.32,115.43 144.84,115.43 144.92,115.36 144.92,113.91 145.02,113.81 145.22,113.81 145.33,113.91 145.33,114.46 145.45,114.58 145.75,114.58 145.85,114.69 145.85,114.89 145.75,114.99 145.45,114.99 145.35,115.09 145.35,115.33 145.45,115.43 146.74,115.43 148.17,116.85 153.75,116.85 153.75,116.86 155.01,116.86 157.3,116.85 157.41,116.96 157.41,117.24 157.51,117.34 157.71,117.34 157.81,117.24 157.81,116.96 157.91,116.85 158.78,116.85 160.32,118.4 162.23,118.4 162.74,117.9 164.72,117.9 164.8,117.81 v1(165.21,117.81)
DDR_A7: length 132.3
  TOP w0.102: v1(132.62,135.69) 132.81,135.5 133.68,135.5 U49.M2 ; U39.M2 134.05,165.63 133.7,165.98 132.81,165.98 v1(132.62,166.17) ; U27.M2 134.05,180.87 133.7,181.22 132.81,181.22 v1(132.62,181.41) 129.32,181.41 129.03,181.12 127.89,181.12 127.51,181.5 R237.1 ; v1(132.62,120.45) 132.81,120.26 133.68,120.26 U52.M2 ; U1.AB15 v1(166.01,117.01) ; v1(132.62,150.93) 132.81,150.74 133.7,150.74 134.05,150.39 U45.M2
  L03_SIG1 w0.102: v1(166.01,117.01) 166.39,116.63 166.39,116.06 166.17,115.83 164.84,115.83 163.4,114.39 163.09,114.39 162.5,113.8 160.87,113.8 159.96,112.89 157.48,112.89 157.45,112.92 155.45,112.92 155.35,112.82 155.35,112.41 155.25,112.31 155.05,112.31 154.95,112.41 154.95,112.84 154.86,112.92 154.13,112.92 153.16,111.95 149.22,111.95 148.62,111.34 144.98,111.34 143.36,109.72 134.11,109.72 132.19,111.64 132.19,112.19 132.17,112.2 132.18,112.21 132.18,115.03 132.66,115.52 132.66,116.45 132.5,116.61 132.18,116.61 132.08,116.71 132.08,116.91 132.18,117.01 132.42,117.01 132.61,117.2 132.61,117.89 132.97,118.25 132.97,120.1 v1(132.62,120.45) 132.13,120.94 132.13,121.81 132.36,122.04 132.36,123.6 132.26,123.71 132.26,124.01 132.36,124.11 132.36,124.42 132.26,124.52 132.26,124.82 132.36,124.92 132.36,125.23 132.26,125.33 132.26,125.64 132.36,125.74 132.36,128.82 132.97,129.43 132.97,131.18 133.58,131.79 133.58,132.32 132.84,133.06 132.84,133.47 132.91,133.53 132.91,135.4 v1(132.62,135.69) 132.18,136.13 132.18,136.46 132.17,136.47 132.17,136.79 132.18,136.8 132.18,137.56 132.57,137.95 132.57,138.72 132.47,138.82 132.31,138.82 132.21,138.92 132.21,139.23 132.31,139.33 132.47,139.33 132.57,139.43 132.57,144.65 132.92,145 132.92,146.79 132.57,147.13 132.57,148.34 133.02,148.78 133.02,150.53 v1(132.62,150.93) 133.05,151.36 133.05,152.01 132.57,152.48 132.57,152.72 132.68,152.82 133.1,152.82 133.2,152.92 133.2,153.22 133.1,153.33 132.68,153.33 132.57,153.43 132.57,160.28 132.84,160.54 132.84,162.17 132.72,162.3 132.72,163.79 132.94,164.02 132.94,165.84 v1(132.62,166.17) 132.17,166.61 132.17,167.72 132.57,168.12 132.57,172.07 132.47,172.17 132.31,172.17 132.21,172.27 132.21,172.58 132.31,172.68 132.47,172.68 132.57,172.78 132.57,173.09 132.47,173.19 132.31,173.19 132.21,173.29 132.21,173.6 132.31,173.7 132.47,173.7 132.57,173.8 132.57,175.23 132.87,175.53 132.87,177.38 132.72,177.53 132.72,178.53 132.87,178.68 132.87,181.16 v1(132.62,181.41)
DDR_A8: length 134.2
  TOP w0.102: U39.N8 132.98,160.81 132.97,160.81 131.16,160.81 v1(131.14,160.78) ; v1(131.14,145.54) 131.16,145.57 132.9,145.57 132.9,145.57 U45.N8 ; U27.N8 132.87,176.05 132.87,176.05 131.16,176.05 v1(131.14,176.02) 131.14,174.33 127.64,170.83 R247.1 ; U49.N8 132.87,130.33 132.87,130.33 132.55,130.33 132.49,130.39 v1(132.08,130.39) ; v1(131.68,114.42) 132.35,115.09 U52.N8 ; U1.AC17 v1(165.21,115.41)
  L03_SIG1 w0.102: v1(131.14,176.02) 131.14,166.84 132.03,165.95 132.03,165.93 132.09,165.87 132.09,164.13 131.64,163.68 131.64,161.9 131.98,161.56 131.98,161.05 131.71,160.78 v1(131.14,160.78) 131.09,160.73 131.09,152.74 131.17,152.67 131.6,152.67 131.7,152.56 131.7,152.26 131.6,152.16 131.19,152.16 131.06,152.03 131.06,151.69 132.03,150.72 132.03,150.69 132.26,150.46 132.26,149.52 131.75,149.01 131.75,145.99 131.57,145.81 131.4,145.81 131.14,145.55 v1(131.14,145.54) 131.04,145.44 131.04,136.76 131.47,136.33 131.47,135.9 132.05,135.31 132.05,133.42 131.75,133.11 131.75,131.26 132.08,130.92 v1(132.08,130.39) 131.68,130.39 131.34,130.06 131.34,122.36 131.32,122.33 131.32,120.82 132.21,119.93 132.21,118.78 132.09,118.66 132.09,118.62 131.83,118.35 131.83,114.98 131.68,114.83 v1(131.68,114.42) 131.68,111.39 133.86,109.21 135.71,109.21 135.81,109.31 136.11,109.31 136.21,109.21 136.52,109.21 136.62,109.31 136.93,109.31 137.03,109.21 137.33,109.21 137.43,109.31 137.74,109.31 137.84,109.21 138.15,109.21 138.25,109.31 138.55,109.31 138.65,109.21 138.96,109.21 139.06,109.31 139.36,109.31 139.47,109.21 139.77,109.21 139.87,109.31 140.18,109.31 140.28,109.21 140.58,109.21 140.69,109.31 140.99,109.31 141.09,109.21 141.4,109.21 141.5,109.31 141.8,109.31 141.9,109.21 142.21,109.21 142.31,109.31 142.62,109.31 142.72,109.21 143.48,109.21 145.01,110.73 148.7,110.73 149.41,111.44 149.64,111.44 149.74,111.34 149.74,110.76 149.84,110.66 150.05,110.66 150.15,110.76 150.15,111.34 150.25,111.44 152.42,111.44 152.52,111.34 152.52,110.63 152.62,110.53 152.85,110.53 152.95,110.63 152.95,111.42 153.06,111.52 153.26,111.52 153.36,111.42 153.36,110.63 153.46,110.53 153.86,110.53 153.97,110.63 153.97,111.98 154.07,112.08 154.27,112.08 154.37,111.98 154.37,111.75 154.47,111.65 155.3,111.65 155.4,111.55 155.4,111.34 155.3,111.24 154.47,111.24 154.37,111.14 154.37,110.63 154.47,110.53 155.12,110.53 156.49,111.9 157.52,111.9 158.03,112.41 160.06,112.41 161.04,113.39 162.63,113.39 163.42,114.18 163.44,114.18 163.45,114.19 163.58,114.19 164.8,115.41 v1(165.21,115.41)
DDR_A9: length 133.3
  TOP w0.102: v1(132.47,133.75) 133.16,133.75 133.46,133.75 133.77,134.06 133.77,134.06 U49.M3 ; R241.1 127.76,178.45 129.05,179.74 131.28,179.74 131.55,179.47 v1(132.47,179.47) 133.16,179.47 133.46,179.47 133.77,179.78 133.77,179.78 U27.M3 ; U52.M3 133.77,118.82 133.77,118.82 133.46,118.51 133.16,118.51 v1(132.47,118.51) ; U39.M3 133.77,164.54 133.77,164.54 133.46,164.23 133.16,164.23 v1(132.47,164.23) ; v1(132.47,148.99) 133.16,148.99 133.46,148.99 133.77,149.3 133.77,149.3 U45.M3 ; U1.AB17 v1(166.01,115.41)
  L03_SIG1 w0.102: v1(132.47,179.47) 132.47,177.42 132.62,177.28 132.62,175.91 132.35,175.64 132.2,175.64 132.02,175.83 131.87,175.83 131.66,175.62 131.66,175.47 131.85,175.29 131.85,175.14 131.65,174.94 131.65,166.62 132.24,166.03 132.24,166.01 132.74,165.51 132.74,164.49 v1(132.47,164.23) 132.18,163.93 132.18,162.48 132.64,162.02 132.64,161.03 131.67,160.07 131.67,158.82 131.95,158.54 131.95,155.79 131.85,155.69 131.75,155.69 131.65,155.59 131.65,155.38 131.75,155.28 131.85,155.28 131.95,155.18 131.95,153.69 131.85,153.59 131.7,153.59 131.6,153.49 131.6,153.18 131.7,153.08 131.85,153.08 131.95,152.98 131.95,151.09 132.24,150.81 132.24,150.77 132.46,150.55 132.46,149.44 132.46,149.43 132.46,149 v1(132.47,148.99) 132.14,148.65 132.14,147.28 132.64,146.78 132.64,145.73 132.46,145.55 132.32,145.55 132.2,145.67 132.05,145.67 131.84,145.46 131.84,145.31 131.96,145.2 131.96,145.05 131.7,144.79 131.7,144.48 131.69,144.47 131.69,144.15 131.7,144.14 131.7,136.11 132.24,135.56 132.24,135.41 132.47,135.18 v1(132.47,133.75) 132.47,132.97 132.72,132.73 132.72,132.52 132.61,132.42 132.23,132.42 132.13,132.31 132.13,132.01 132.23,131.91 132.61,131.91 132.72,131.81 132.72,130.32 131.85,129.45 131.85,120.66 132.47,120.04 v1(132.47,118.51)
  L08_SIG2 w0.102: v1(132.47,118.51) 132.76,118.22 132.76,116.5 132.97,116.3 132.97,114.92 133.92,113.97 133.92,113.73 134.03,113.63 134.23,113.63 134.33,113.73 134.33,113.97 134.43,114.07 136.21,114.07 137.21,113.07 137.23,113.07 137.46,112.83 137.46,112.82 138.35,111.93 146.23,111.93 146.3,112 148.44,112 148.51,111.93 149.04,111.93 149.16,112.05 149.16,112.54 149.27,112.64 149.47,112.64 149.57,112.54 149.57,112 149.65,111.93 151.58,111.93 151.68,112.03 151.68,112.26 151.58,112.36 150.04,112.36 149.94,112.46 149.94,112.66 150.04,112.77 150.27,112.77 150.37,112.87 150.37,113.07 150.47,113.17 150.67,113.17 150.77,113.07 150.77,112.87 150.88,112.77 151.58,112.77 151.68,112.87 151.68,113.15 151.78,113.25 151.99,113.25 152.09,113.15 152.09,112.03 152.19,111.93 152.96,111.93 153.37,112.33 153.42,112.33 153.6,112.52 153.6,112.66 153.53,112.73 153.53,112.88 153.67,113.02 153.81,113.02 153.89,112.95 154.03,112.95 155.63,114.54 156.18,114.54 156.44,114.81 158.05,114.81 158.42,114.45 161.1,114.45 161.31,114.23 162.74,114.23 163.33,114.82 163.6,114.82 163.69,114.91 163.69,115.75 164.01,116.07 164.77,116.07 165.02,115.81 165.61,115.81 v1(166.01,115.41)
DDR_A10: length 135.2
  TOP w0.102: U52.H7 137.44,116.08 137.44,116.27 v1(137.77,116.6) ; U49.H7 137.44,131.32 137.44,131.51 v1(137.77,131.84) ; R306.1 v2(144.78,185.94) ; U45.H7 137.54,146.66 v1(137.54,147) ; U27.H7 137.52,177.12 137.66,177.26 137.66,177.35 v1(137.95,177.64) ; v1(137.77,162.32) 137.44,161.99 137.44,161.8 U39.H7 ; U1.AB14 v1(166.01,117.81)
  L03_SIG1 w0.102: v2(144.78,185.94) 144.78,185.59 143.74,184.55 143.36,184.55 141,182.18 141,181.6 138.66,179.27 138.66,178.78 137.95,178.07 v1(137.95,177.64)
  L08_SIG2 w0.102: v1(166.01,117.81) 165.6,117.41 164.77,117.41 164.66,117.51 164.66,118.15 164.56,118.25 164.36,118.25 164.26,118.15 164.26,117.51 164.16,117.41 163.93,117.41 163.83,117.51 163.83,118.15 163.72,118.25 163.52,118.25 163.42,118.15 163.42,117.51 163.32,117.41 163.09,117.41 162.99,117.51 162.99,118.15 162.89,118.25 162.68,118.25 162.58,118.15 162.58,117.51 162.48,117.41 160.99,117.41 160.54,116.96 159.97,116.96 159.54,117.39 156.26,117.39 155.73,117.92 155.19,117.92 154,116.73 153.5,116.73 153.4,116.83 153.4,118 153.3,118.1 153.09,118.1 152.99,118 152.99,116.83 152.89,116.73 152.66,116.73 152.56,116.83 152.56,118.02 152.46,118.12 152.25,118.12 152.15,118.02 152.15,116.83 152.05,116.73 151.76,116.73 151.66,116.83 151.66,118.2 151.56,118.3 151.36,118.3 151.26,118.2 151.26,116.83 150.96,116.54 149.82,116.54 146.91,113.63 145.59,113.63 145.54,113.58 144.75,113.58 144.48,113.86 144.48,114.64 144.58,114.75 145.36,114.75 145.47,114.85 145.47,115.05 145.36,115.15 144.58,115.15 144.48,115.25 144.48,115.46 144.58,115.56 145.36,115.56 145.47,115.66 145.47,115.86 145.36,115.97 144.58,115.97 144.48,116.07 144.48,116.7 143.81,117.36 142.6,117.36 141.57,116.33 140.3,116.33 139.93,116.69 138.28,116.69 138.18,116.6 v1(137.77,116.6) 137.77,118.41 138.04,118.67 138.04,122.07 138.56,122.6 138.56,127.14 138.02,127.68 138.02,128.23 137.92,128.34 137.54,128.34 137.44,128.44 137.44,128.74 137.54,128.84 137.92,128.84 138.02,128.95 138.02,129.77 138.03,129.77 138.03,130.09 138.02,130.09 138.02,130.6 137.77,130.85 v1(137.77,131.84) 137.77,134.36 138.05,134.63 138.05,137.71 137.67,138.09 137.67,141.35 137.77,141.45 138.18,141.45 138.28,141.56 138.28,141.86 138.18,141.96 137.77,141.96 137.67,142.06 137.67,142.53 138.1,142.96 138.1,145.42 137.54,145.97 v1(137.54,147) 137.54,147.87 137.83,148.16 137.83,150.21 138.2,150.58 138.2,151.69 138.1,151.79 137.79,151.79 137.69,151.89 137.69,152.2 137.79,152.3 138.1,152.3 138.56,152.76 138.56,156.85 137.72,157.69 137.72,159.32 138.02,159.63 138.02,160.25 138.03,160.25 138.03,160.57 138.02,160.57 138.02,162.07 v1(137.77,162.32) 137.77,165.41 138.19,165.83 138.19,170.2 138.29,170.3 138.73,170.3 138.84,170.4 138.84,170.71 138.73,170.81 138.29,170.81 138.2,170.89 138.2,176.21 137.95,176.47 v1(137.95,177.64)
DDR_A11: length 134.5
  TOP w0.102: U45.M7 133.68,146.74 132.77,146.74 132.64,146.62 v1(132.24,146.62) ; U49.M7 133.65,131.53 132.8,131.53 132.64,131.38 v1(132.24,131.38) ; U27.M7 133.65,177.25 132.8,177.25 132.64,177.1 v1(132.24,177.1) 131.7,177.1 131.62,177.18 130.73,177.18 127.43,173.88 R305.1 ; U39.M7 133.65,162.01 132.8,162.01 132.64,161.86 v1(132.24,161.86) ; v1(132.24,116.14) 132.64,116.14 132.8,116.29 133.65,116.29 U52.M7 ; U1.AA16 v1(166.81,116.21)
  L08_SIG2 w0.102: v1(132.24,177.1) 132.24,175.81 131.42,175 131.42,166.41 131.85,165.98 131.85,163.43 131.72,163.31 131.19,163.31 131.09,163.2 131.09,162.9 131.19,162.8 131.72,162.8 131.83,162.7 131.83,162.27 v1(132.24,161.86) 132.24,160.6 131.06,159.43 131.06,155.35 131.17,155.24 131.46,155.24 131.56,155.14 131.56,154.84 131.46,154.74 131.17,154.74 131.06,154.64 131.06,153.86 131.85,153.08 131.85,147 v1(132.24,146.62) 132.24,145.26 131.52,144.54 131.52,138.02 131.83,137.71 131.83,136.32 131.72,136.22 131.29,136.22 131.19,136.12 131.19,135.81 131.29,135.71 131.72,135.71 131.84,135.59 131.84,131.78 v1(132.24,131.38) 132.24,131.31 131.7,130.77 131.7,130.04 131.9,129.83 131.9,129.49 131.8,129.39 131.64,129.39 131.54,129.29 131.54,128.98 131.64,128.88 131.8,128.88 131.9,128.78 131.9,121.35 132.21,121.05 132.21,119.37 131.71,118.88 131.71,116.66 v1(132.24,116.14) 132.24,113.9 132.4,113.74 132.4,113.62 131.67,112.89 131.67,112.75 131.81,112.6 131.95,112.6 132.66,113.31 132.83,113.31 133.2,112.94 133.2,112.79 132.5,112.09 132.5,111.95 132.64,111.8 132.79,111.8 133.24,112.26 133.39,112.26 133.49,112.16 133.72,112.16 133.82,112.05 133.82,111.66 133.88,111.6 134.09,111.6 134.11,111.57 134.14,111.57 134.23,111.66 134.23,112.05 134.33,112.16 135.13,112.16 135.26,112.28 135.26,113.17 135.36,113.27 135.56,113.27 135.66,113.17 135.66,112.23 135.74,112.16 136.37,112.16 137.03,111.5 137.4,111.5 137.5,111.39 137.5,111.18 137.59,111.09 137.82,111.09 137.91,111.18 137.91,111.39 138.01,111.5 138.22,111.5 138.32,111.39 138.32,111.18 138.41,111.09 138.43,111.11 138.66,111.11 138.72,111.18 138.72,111.39 138.82,111.5 139.03,111.5 139.13,111.39 139.13,111.18 139.19,111.11 139.47,111.11 139.54,111.18 139.54,111.39 139.64,111.5 146.38,111.5 146.48,111.6 148.26,111.6 148.36,111.5 153.1,111.5 153.13,111.52 153.26,111.52 155.52,113.78 156.85,113.78 157.28,114.21 158.06,114.21 158.41,113.86 162.69,113.86 163.3,114.47 163.58,114.47 164.12,115.01 166.21,115.01 166.4,115.2 166.4,115.81 v1(166.81,116.21)
DDR_A12: length 136
  TOP w0.102: U1.AA17 v1(166.81,115.41) ; v1(134.8,177.52) 134.97,177.36 135.27,177.36 135.65,176.97 U27.K7 ; R307.1 v2(129.54,185.94) ; U49.K7 135.35,131.43 135.17,131.43 v1(134.8,131.8) ; v1(134.8,116.56) 135.17,116.19 135.35,116.19 U52.K7 ; U45.K7 135.65,146.49 135.1,147.04 v1(134.8,147.04) ; U39.K7 135.65,161.73 135.27,162.12 134.97,162.12 v1(134.8,162.28)
  L03_SIG1 w0.102: v1(134.8,177.52) 134.8,177.11 134.85,177.07 134.85,174.79 135.43,174.21 135.43,173.27 135.33,173.17 135.1,173.17 135,173.06 135,172.76 135.1,172.66 135.33,172.66 135.43,172.56 135.43,172.25 135.33,172.15 135.1,172.15 135,172.05 135,171.74 135.1,171.64 135.33,171.64 135.43,171.54 135.43,167.53 134.87,166.96 134.87,165.86 134.92,165.8 134.92,163.57 134.8,163.45 v1(134.8,162.28) 134.8,160.78 135.21,160.37 135.21,155.29 135.11,155.19 134.82,155.19 134.72,155.09 134.72,154.78 134.82,154.68 135.11,154.68 135.21,154.58 135.21,154.28 135.11,154.17 134.82,154.17 134.72,154.07 134.72,153.77 134.82,153.67 135.11,153.67 135.22,153.55 135.22,152.08 134.92,151.78 134.92,150.99 134.87,150.93 134.87,150.62 134.92,150.56 134.92,148.09 134.8,147.97 v1(134.8,147.04) 134.8,145.7 135.25,145.25 135.25,141.74 135.15,141.64 134.7,141.64 134.59,141.54 134.59,141.24 134.7,141.13 135.15,141.13 135.36,140.93 135.36,136.97 134.85,136.46 134.85,133.74 134.89,133.7 134.89,133.2 134.8,133.12 v1(134.8,131.8) 134.8,130.46 135.21,130.05 135.21,129.39 135.11,129.29 134.65,129.29 134.54,129.19 134.54,128.89 134.65,128.78 135.11,128.78 135.23,128.66 135.23,121.66 134.87,121.29 134.87,118.48 134.89,118.46 134.89,117.39 134.87,117.38 134.87,116.63 v1(134.8,116.56)
  L08_SIG2 w0.102: v1(134.8,177.52) 134.8,178.2 134.89,178.28 134.89,180.55 132.71,182.73 132.69,182.73 130.88,184.55 130.58,184.55 129.54,185.59 v2(129.54,185.94)
  BOTTOM w0.102: v1(134.8,116.56) 134.8,116 134.67,115.86 134.67,115.31 136.3,113.68 136.86,113.68 136.96,113.58 136.96,113.17 137.06,113.07 137.29,113.07 137.39,113.17 137.39,113.61 137.52,113.73 137.78,113.73 137.93,113.58 137.93,111.67 138.03,111.57 138.24,111.57 138.34,111.67 138.34,113.58 138.44,113.68 138.99,113.68 139.42,113.25 139.42,112.36 140.39,111.39 149.34,111.39 151.49,113.54 151.49,113.68 151.34,113.83 151.34,113.97 151.49,114.11 151.63,114.11 151.78,113.97 151.92,113.97 152.28,114.33 153.06,114.33 153.17,114.44 153.17,115.2 153.3,115.33 153.53,115.33 153.63,115.23 153.63,115.15 153.73,115.05 153.93,115.05 154.03,115.15 154.03,115.23 154.14,115.33 154.34,115.33 154.44,115.23 154.44,115.15 154.54,115.05 154.75,115.05 154.85,115.15 154.85,115.23 154.95,115.33 155.15,115.33 155.25,115.23 155.25,115.15 155.35,115.05 155.56,115.05 155.66,115.15 155.66,115.23 155.76,115.33 155.96,115.33 156.07,115.23 156.07,115.15 156.17,115.05 156.37,115.05 156.47,115.15 156.47,115.23 156.62,115.38 157.34,115.38 157.87,114.85 158.43,114.85 158.56,114.98 159.08,114.98 159.3,114.77 159.3,113.97 159.38,113.88 159.56,113.88 159.74,114.06 159.74,115.33 159.84,115.43 160.04,115.43 160.17,115.31 160.17,113.88 160.25,113.81 160.45,113.81 160.55,113.91 160.55,114.72 160.86,115.03 163.37,115.03 164.19,115.84 165.05,115.84 165.05,115.83 165.37,115.83 165.37,115.84 165.85,115.84 165.85,115.83 166.17,115.83 166.17,115.84 166.38,115.84 v1(166.81,115.41)
DDR_A13: length 131.7
  TOP w0.102: v1(131.46,164.89) 131.86,164.89 131.94,164.81 U39.N3 ; U45.N3 131.94,149.57 131.86,149.65 v1(131.46,149.65) ; R309.1 128.57,179.97 128.84,180.25 131.27,180.25 131.43,180.09 v1(131.46,180.13) 131.86,180.13 131.94,180.05 U27.N3 ; U52.N3 131.94,119.09 131.86,119.17 v1(131.46,119.17) ; v1(131.46,134.41) 131.86,134.41 131.94,134.33 U49.N3
  TOP w0.127: U1.AA12 v1(166.81,120.21)
  L08_SIG2 w0.102: v1(131.46,119.17) 131.95,119.66 131.95,120.72 131.37,121.3 131.37,128.23 130.89,128.72 130.89,132.41 130.99,132.51 131.27,132.51 131.37,132.61 131.37,132.92 131.27,133.02 130.99,133.02 130.89,133.12 130.89,133.84 v1(131.46,134.41) 130.77,135.09 130.77,136.52 130.87,136.62 131.24,136.62 131.34,136.72 131.34,137.03 131.24,137.13 130.87,137.13 130.78,137.22 130.78,145.36 130.76,145.38 130.76,147.56 131.46,148.26 v1(131.46,149.65) 130.49,150.61 130.49,151.86 130.59,151.97 130.96,151.97 131.06,152.07 131.06,152.37 130.96,152.47 130.59,152.47 130.49,152.58 130.49,163.92 v1(131.46,164.89) 130.76,165.59 130.76,178.1 130.87,178.21 131.34,178.21 131.44,178.31 131.44,178.62 131.34,178.72 130.87,178.72 130.77,178.82 130.77,179.44 v1(131.46,180.13)
  BOTTOM w0.102: v1(166.81,120.21) 166.39,120.63 165.07,120.63 164.52,120.08 162.79,120.08 162.48,120.39 161.82,120.39 160.2,122.01 154.33,122.01 153.97,121.65 153.97,120.53 153.82,120.39 152.85,120.39 152.75,120.49 152.75,121.39 152.65,121.49 152.44,121.49 152.34,121.39 152.34,120.49 152.24,120.39 152.04,120.39 151.94,120.49 151.94,121.21 151.84,121.31 151.63,121.31 151.53,121.21 151.53,120.49 151.43,120.39 151.23,120.39 151.12,120.49 151.12,121.21 151.02,121.31 150.82,121.31 150.72,121.21 150.72,120.49 150.62,120.39 150.41,120.39 150.31,120.49 150.31,121.21 150.21,121.31 149.89,121.31 149.79,121.21 149.79,120.49 149.69,120.39 149.48,120.39 149.38,120.49 149.38,121.26 149.28,121.36 148.89,121.36 148.79,121.26 148.79,120.72 148.68,120.61 148.48,120.61 148.38,120.72 148.38,121.95 148.32,122.01 147.98,122.01 147.97,122.02 147.91,121.95 147.91,120.64 146.53,119.27 139.83,119.27 139.46,118.9 131.72,118.9 v1(131.46,119.17)
