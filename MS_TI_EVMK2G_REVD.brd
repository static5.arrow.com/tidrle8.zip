# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CON_DB9_182-009-113R531_P_R_T
  rect 1.753x1.753 hole 1.118: 1(0,0)
  round 1.753 hole 1.118: 2(2.769,0) 3(5.537,0) 4(8.306,0) 5(11.074,0) 6(1.384,-2.845) 7(4.153,-2.845) 8(6.921,-2.845) 9(9.69,-2.845)
  round 4.064 hole 3.048: 10(18.034,-1.422) 11(-6.96,-1.422)
CON_ED50X2_MEC6-150_S_R_S
  round 1.448 hole 1.575 unplated: (-18.339,0) (18.339,0)
  rect 0.406x2.007 smd: 1(-17.145,-4) 2(-17.145,4) 3(-16.51,-4) 4(-16.51,4) 5(-15.875,-4) 6(-15.875,4) 7(-15.24,-4) 8(-15.24,4) 9(-14.605,-4) 10(-14.605,4) 11(-13.97,-4) 12(-13.97,4) 13(-13.335,-4) 14(-13.335,4) 15(-12.7,-4) 16(-12.7,4) 17(-12.065,-4) 18(-12.065,4) 19(-11.43,-4) 20(-11.43,4) 21(-10.795,-4) 22(-10.795,4) 23(-10.16,-4) 24(-10.16,4) 25(-9.525,-4) 26(-9.525,4) 27(-8.89,-4) 28(-8.89,4) 29(-8.255,-4) 30(-8.255,4) 31(-7.62,-4) 32(-7.62,4) 33(-6.985,-4) 34(-6.985,4) 35(-6.35,-4) 36(-6.35,4) 37(-5.715,-4) 38(-5.715,4) 39(-5.08,-4) 40(-5.08,4) 41(-4.445,-4) 42(-4.445,4) 43(-3.81,-4) 44(-3.81,4) 45(-3.175,-4) 46(-3.175,4) 47(-2.54,-4) 48(-2.54,4) 49(-1.905,-4) 50(-1.905,4) 51(-1.27,-4) 52(-1.27,4) 53(-0.635,-4) 54(-0.635,4) 55(0,-4) 56(0,4) 57(0.635,-4) 58(0.635,4) 59(1.27,-4) 60(1.27,4) 61(1.905,-4) 62(1.905,4) 63(5.715,-4) 64(5.715,4) 65(6.35,-4) 66(6.35,4) 67(6.985,-4) 68(6.985,4) 69(7.62,-4) 70(7.62,4) 71(8.255,-4) 72(8.255,4) 73(8.89,-4) 74(8.89,4) 75(9.525,-4) 76(9.525,4) 77(10.16,-4) 78(10.16,4) 79(10.795,-4) 80(10.795,4) 81(11.43,-4) 82(11.43,4) 83(12.065,-4) 84(12.065,4) 85(12.7,-4) 86(12.7,4) 87(13.335,-4) 88(13.335,4) 89(13.97,-4) 90(13.97,4) 91(14.605,-4) 92(14.605,4) 93(15.24,-4) 94(15.24,4) 95(15.875,-4) 96(15.875,4) 97(16.51,-4) 98(16.51,4) 99(17.145,-4) 100(17.145,4)
CON_FLEX40X1_62684-40_S_R_S
  rect 2.413x2.413 smd: (-11.85,-0.101) (11.85,-0.101)
  rect 0.305x1.194 smd: 1(9.75,-2.8) 2(9.25,-2.8) 3(8.75,-2.8) 4(8.25,-2.8) 5(7.75,-2.8) 6(7.25,-2.8) 7(6.75,-2.8) 8(6.25,-2.8) 9(5.75,-2.8) 10(5.25,-2.8) 11(4.75,-2.8) 12(4.25,-2.8) 13(3.75,-2.8) 14(3.25,-2.8) 15(2.75,-2.8) 16(2.25,-2.8) 17(1.75,-2.8) 18(1.25,-2.8) 19(0.75,-2.8) 20(0.25,-2.8) 21(-0.25,-2.8) 22(-0.75,-2.8) 23(-1.25,-2.8) 24(-1.75,-2.8) 25(-2.25,-2.8) 26(-2.75,-2.8) 27(-3.25,-2.8) 28(-3.75,-2.8) 29(-4.25,-2.8) 30(-4.75,-2.8) 31(-5.25,-2.8) 32(-5.75,-2.8) 33(-6.25,-2.8) 34(-6.75,-2.8) 35(-7.25,-2.8) 36(-7.75,-2.8) 37(-8.25,-2.8) 38(-8.75,-2.8) 39(-9.25,-2.8) 40(-9.75,-2.8)
CON_FLEX_6X1_68610_S_R_S
  rect 0.61x2.21 smd: 1(-2.5,4.406) 2(-1.5,4.406) 3(-0.5,4.406) 4(0.5,4.406) 5(1.5,4.406) 6(2.5,4.406)
  rect 1.803x2.616 smd: 7(-5.1,2.006) 8(5.1,2.006)
CON_PCI_18X2_10061913_S_S_S
  round 1.143 hole 1.27 unplated: (2.15,0) (11.3,0)
  rect 0.711x2.007 smd: A1(-9.5,3.6) A2(-8.5,3.6) A3(-7.5,3.6) A4(-6.5,3.6) A5(-5.5,3.6) A6(-4.5,3.6) A7(-3.5,3.6) A8(-2.5,3.6) A9(-1.5,3.6) A10(-0.5,3.6) A11(0.5,3.6) A12(3.5,3.6) A13(4.5,3.6) A14(5.5,3.6) A15(6.5,3.6) A16(7.5,3.6) A17(8.5,3.6) A18(9.5,3.6) B1(-9.5,-3.6) B2(-8.5,-3.6) B3(-7.5,-3.6) B4(-6.5,-3.6) B5(-5.5,-3.6) B6(-4.5,-3.6) B7(-3.5,-3.6) B8(-2.5,-3.6) B9(-1.5,-3.6) B10(-0.5,-3.6) B11(0.5,-3.6) B12(3.5,-3.6) B13(4.5,-3.6) B14(5.5,-3.6) B15(6.5,-3.6) B16(7.5,-3.6) B17(8.5,-3.6) B18(9.5,-3.6)
  rect 3.023x5.004 smd: SH1(-12.5,0) SH2(12.5,0)
CON_PMC20X2_QSH-D-DP_S_S_S
  round 0.889 hole 1.016 unplated: (-9.56,2.67) (10.573,2.67)
  rect 0.279x2.286 smd: 1(-6.75,-2.87) 2(-6.75,2.87) 3(-6.25,-2.87) 4(-6.25,2.87) 5(-5.25,-2.87) 6(-5.25,2.87) 7(-4.75,-2.87) 8(-4.75,2.87) 9(-3.75,-2.87) 10(-3.75,2.87) 11(-3.25,-2.87) 12(-3.25,2.87) 13(-2.25,-2.87) 14(-2.25,2.87) 15(-1.75,-2.87) 16(-1.75,2.87) 17(-0.75,-2.87) 18(-0.75,2.87) 19(-0.25,-2.87) 20(-0.25,2.87) 21(0.75,-2.87) 22(0.75,2.87) 23(1.25,-2.87) 24(1.25,2.87) 25(2.25,-2.87) 26(2.25,2.87) 27(2.75,-2.87) 28(2.75,2.87) 29(3.75,-2.87) 30(3.75,2.87) 31(4.25,-2.87) 32(4.25,2.87) 33(5.25,-2.87) 34(5.25,2.87) 35(5.75,-2.87) 36(5.75,2.87) 37(6.75,-2.87) 38(6.75,2.87) 39(7.25,-2.87) 40(7.25,2.87)
  rect 2.54x0.432 smd: 41(-8.065,0) 44(8.065,0)
  rect 4.699x0.432 smd: 42(3.175,0) 43(-3.175,0)
CON_PMC30X2_HQCD-030_S_S_S
  round 0.889 hole 1.016 unplated: (-10.065,2.67) (10.065,2.67)
  rect 0.279x2.286 smd: 1(-7.25,-2.87) 2(-7.25,2.87) 3(-6.75,-2.87) 4(-6.75,2.87) 5(-6.25,-2.87) 6(-6.25,2.87) 7(-5.75,-2.87) 8(-5.75,2.87) 9(-5.25,-2.87) 10(-5.25,2.87) 11(-4.75,-2.87) 12(-4.75,2.87) 13(-4.25,-2.87) 14(-4.25,2.87) 15(-3.75,-2.87) 16(-3.75,2.87) 17(-3.25,-2.87) 18(-3.25,2.87) 19(-2.75,-2.87) 20(-2.75,2.87) 21(-2.25,-2.87) 22(-2.25,2.87) 23(-1.75,-2.87) 24(-1.75,2.87) 25(-1.25,-2.87) 26(-1.25,2.87) 27(-0.75,-2.87) 28(-0.75,2.87) 29(-0.25,-2.87) 30(-0.25,2.87) 31(0.25,-2.87) 32(0.25,2.87) 33(0.75,-2.87) 34(0.75,2.87) 35(1.25,-2.87) 36(1.25,2.87) 37(1.75,-2.87) 38(1.75,2.87) 39(2.25,-2.87) 40(2.25,2.87) 41(2.75,-2.87) 42(2.75,2.87) 43(3.25,-2.87) 44(3.25,2.87) 45(3.75,-2.87) 46(3.75,2.87) 47(4.25,-2.87) 48(4.25,2.87) 49(4.75,-2.87) 50(4.75,2.87) 51(5.25,-2.87) 52(5.25,2.87) 53(5.75,-2.87) 54(5.75,2.87) 55(6.25,-2.87) 56(6.25,2.87) 57(6.75,-2.87) 58(6.75,2.87) 59(7.25,-2.87) 60(7.25,2.87)
  rect 2.54x0.432 smd: 61(8.065,0) 62(-8.065,0)
  rect 4.724x0.432 smd: 63(3.175,0) 64(-3.175,0)
CON_PWRJACK3_RAPC722_P_R_T
  rect 4.826x2.032 hole 3.556x1.016: 1(0,0.024)
  rect 4.064x1.778 hole 3.048x0.762: 2(0,-6.226)
  rect 1.778x4.064 hole 0.762x3.048: 3(4.8,-2.976)
CON_RJ45-14_LPJG16314A4NL_S_R_T
  round 3.073 hole 3.2 unplated: (0,-8.89) (11.43,-8.89)
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(1.27,-2.54) 3(2.54,0) 4(3.81,-2.54) 5(5.08,0) 6(6.35,-2.54) 7(7.62,0) 8(8.89,-2.54) 9(10.16,0) 10(11.43,-2.54)
  round 1.702 hole 1.016: 11(12.44,-11.43) 12(12.44,-13.462) 13(-1.01,-11.43) 14(-1.01,-13.462)
  round 2.362 hole 1.676: 15(-2.032,-5.842) 16(13.462,-5.842)
CON_SD_8_DM3AT-SF-PEJM_S_R_S
  rect 0.711x1.219 smd: 1(3.3,7.33) 2(2.2,7.33) 3(1.1,7.33) 4(0,7.33) 5(-1.1,7.33) 6(-2.2,7.33) 7(-3.3,7.33) 8(-4.4,7.33) 9(-5.5,7.33)
  rect 1.016x1.219 smd: 10(4.85,7.33) 11(-6.317,3.02)
  rect 0.813x1.016 smd: 12(-6.317,-3.18)
  rect 1.016x2.819 smd: 13(-6.317,-7.33)
  rect 1.321x1.905 smd: 14(7.21,-7.78)
CON_USBA4_87583-2010_S_R_S
  rect 1.168x2.87 smd: 1(-3.5,6.875) 2(-1,6.875) 3(1,6.875) 4(3.5,6.875)
  round 2.997 hole 2.286: 5(-6.57,3.295) 6(6.57,3.295)
CON_USBAB5_54819-0572_S_R_S
  rect 2.311x0.559 smd: 1(3.692,1.6) 2(3.692,0.8) 3(3.692,0) 4(3.692,-0.8) 5(3.692,-1.6)
  rect 3.556x2.108 smd: 6(3.717,4.925) 9(3.717,-4.925)
  rect 3.683x2.108 smd: 7(-0.343,4.925) 8(-0.343,-4.925)
CON_USBAB5_ZX62_P_R_S
  rect 1.905x1.905 smd: (-1.2,0) (1.2,0)
  rect 0.406x1.372 smd: 1(-1.3,2.675) 2(-0.65,2.675) 3(0,2.675) 4(0.65,2.675) 5(1.3,2.675)
  rect 2.108x1.6 smd: 6(-3.1,2.55) 7(3.1,2.55)
  rect 1.803x1.905 smd: 8(-4,0) 9(4,0)
CON_USBB5_54819-0511_S_R_T
  oval 1.118x1.651 hole 0.711: 1(0,0) 2(0.8,-1.2) 3(1.6,0) 4(2.4,-1.2) 5(3.2,0)
  rect 1.803x2.819 hole 0.762x1.93: 6(-2.05,-5.05) 7(5.25,-5.05)
D2PAK-3
  rect 1.27x3.429 smd: 1(-2.54,-6.229) 3(2.54,-6.229)
  rect 10.668x9.017 smd: 4(0,3.677)
DIO_DFN0402
  rect 0.508x0.711 smd: 1(0,0) 2(0.864,0)
DIO_SMA
  rect 1.27x2.108 smd: 1(-1.981,0) 2(1.981,0)
DIO_SMC
  rect 2.413x3.2 smd: 1(-3.4,0) 2(3.4,0)
DIO_SOD123
  rect 1.016x0.813 smd: 1(-1.8,0) 2(1.8,0)
DIO_SOD323
  rect 0.965x0.508 smd: 1(-1.3,0) 2(1.3,0)
DQN_25-59_40X40
  custom 0.088x0.088 smd: 1(-0.325,-0.365) 2(0.325,-0.435) 3(0.325,0.435) 4(-0.325,0.435)
  custom 0.204x0.204 smd: 5(0,0)
DSBGA4_19-68_40X40
  round 0.229 smd: A1(-0.25,0.25) A2(0.25,0.25) B1(-0.25,-0.25) B2(0.25,-0.25)
EMIFIL_BLM15H_0402
  rect 0.914x0.711 smd: 1(-0.65,0) 2(0.65,0)
EMIFIL_BLM18K_0603
  rect 0.94x1.194 smd: 1(-0.825,0) 2(0.825,0)
EMIFIL_BLM18R_0603
  rect 0.94x1.194 smd: 1(-0.825,0) 2(0.825,0)
EMIFIL_BLM31P_1206
  rect 1.6x1.803 smd: 1(-1.4,0) 2(1.4,0)
EMIFIL_NFL21SP_0805
  rect 1.016x2.032 smd: 1(-1.219,0) 3(1.219,0)
  rect 0.61x2.032 smd: 2(0,0)
EMIFIL_NFM18PS_0603
  rect 0.406x0.406 smd: 1(-0.8,0) 3(0.8,0)
  rect 0.813x1.219 smd: 2(0,0)
ESOIC8
  rect 1.549x0.61 smd: 1(-2.7,1.905) 2(-2.7,0.635) 3(-2.7,-0.635) 4(-2.7,-1.905) 5(2.7,-1.905) 6(2.7,-0.635) 7(2.7,0.635) 8(2.7,1.905)
  rect 2.54x3.2 smd: 9(0,0)
FBGA78_31-49_360X420
  round 1.016 smd: (-5.563,-6.299) (5.563,6.299)
  round 0.406 smd: A1(-3.2,4.8) A2(-2.4,4.8) A3(-1.6,4.8) A7(1.6,4.8) A8(2.4,4.8) A9(3.2,4.8) B1(-3.2,4) B2(-2.4,4) B3(-1.6,4) B7(1.6,4) B8(2.4,4) B9(3.2,4) C1(-3.2,3.2) C2(-2.4,3.2) C3(-1.6,3.2) C7(1.6,3.2) C8(2.4,3.2) C9(3.2,3.2) D1(-3.2,2.4) D2(-2.4,2.4) D3(-1.6,2.4) D7(1.6,2.4) D8(2.4,2.4) D9(3.2,2.4) E1(-3.2,1.6) E2(-2.4,1.6) E3(-1.6,1.6) E7(1.6,1.6) E8(2.4,1.6) E9(3.2,1.6) F1(-3.2,0.8) F2(-2.4,0.8) F3(-1.6,0.8) F7(1.6,0.8) F8(2.4,0.8) F9(3.2,0.8) G1(-3.2,0) G2(-2.4,0) G3(-1.6,0) G7(1.6,0) G8(2.4,0) G9(3.2,0) H1(-3.2,-0.8) H2(-2.4,-0.8) H3(-1.6,-0.8) H7(1.6,-0.8) H8(2.4,-0.8) H9(3.2,-0.8) J1(-3.2,-1.6) J2(-2.4,-1.6) J3(-1.6,-1.6) J7(1.6,-1.6) J8(2.4,-1.6) J9(3.2,-1.6) K1(-3.2,-2.4) K2(-2.4,-2.4) K3(-1.6,-2.4) K7(1.6,-2.4) K8(2.4,-2.4) K9(3.2,-2.4) L1(-3.2,-3.2) L2(-2.4,-3.2) L3(-1.6,-3.2) L7(1.6,-3.2) L8(2.4,-3.2) L9(3.2,-3.2) M1(-3.2,-4) M2(-2.4,-4) M3(-1.6,-4) M7(1.6,-4) M8(2.4,-4) M9(3.2,-4) N1(-3.2,-4.8) N2(-2.4,-4.8) N3(-1.6,-4.8) N7(1.6,-4.8) N8(2.4,-4.8) N9(3.2,-4.8)
FBGA153_19-68_460X515
  round 1.016 smd: (-6.795,-7.556) (6.795,7.556)
  round 0.229 smd: A1(-3.25,3.25) A2(-2.75,3.25) A3(-2.25,3.25) B1(-3.25,2.75) B3(-2.25,2.75) C1(-3.25,2.25) C3(-2.25,2.25)
  round 0.254 smd: A4(-1.75,3.25) A5(-1.25,3.25) A6(-0.75,3.25) A7(-0.25,3.25) A8(0.25,3.25) A9(0.75,3.25) A10(1.25,3.25) A11(1.75,3.25) A12(2.25,3.25) A13(2.75,3.25) A14(3.25,3.25) B2(-2.75,2.75) B4(-1.75,2.75) B5(-1.25,2.75) B6(-0.75,2.75) B7(-0.25,2.75) B8(0.25,2.75) B9(0.75,2.75) B10(1.25,2.75) B11(1.75,2.75) B12(2.25,2.75) B13(2.75,2.75) B14(3.25,2.75) C2(-2.75,2.25) C4(-1.75,2.25) C5(-1.25,2.25) C6(-0.75,2.25) C7(-0.25,2.25) C8(0.25,2.25) C9(0.75,2.25) C10(1.25,2.25) C11(1.75,2.25) C12(2.25,2.25) C13(2.75,2.25) C14(3.25,2.25) D1(-3.25,1.75) D2(-2.75,1.75) D3(-2.25,1.75) D4(-1.75,1.75) D12(2.25,1.75) D13(2.75,1.75) D14(3.25,1.75) E1(-3.25,1.25) E2(-2.75,1.25) E3(-2.25,1.25) E5(-1.25,1.25) E6(-0.75,1.25) E7(-0.25,1.25) E8(0.25,1.25) E9(0.75,1.25) E10(1.25,1.25) E12(2.25,1.25) E13(2.75,1.25) E14(3.25,1.25) F1(-3.25,0.75) F2(-2.75,0.75) F3(-2.25,0.75) F5(-1.25,0.75) F10(1.25,0.75) F12(2.25,0.75) F13(2.75,0.75) F14(3.25,0.75) G1(-3.25,0.25) G2(-2.75,0.25) G3(-2.25,0.25) G5(-1.25,0.25) G10(1.25,0.25) G12(2.25,0.25) G13(2.75,0.25) G14(3.25,0.25) H1(-3.25,-0.25) H2(-2.75,-0.25) H3(-2.25,-0.25) H5(-1.25,-0.25) H10(1.25,-0.25) H12(2.25,-0.25) H13(2.75,-0.25) H14(3.25,-0.25) J1(-3.25,-0.75) J2(-2.75,-0.75) J3(-2.25,-0.75) J5(-1.25,-0.75) J10(1.25,-0.75) J12(2.25,-0.75) J13(2.75,-0.75) J14(3.25,-0.75) K1(-3.25,-1.25) K2(-2.75,-1.25) K3(-2.25,-1.25) K5(-1.25,-1.25) K6(-0.75,-1.25) K7(-0.25,-1.25) K8(0.25,-1.25) K9(0.75,-1.25) K10(1.25,-1.25) K12(2.25,-1.25) K13(2.75,-1.25) K14(3.25,-1.25) L1(-3.25,-1.75) L2(-2.75,-1.75) L3(-2.25,-1.75) L12(2.25,-1.75) L13(2.75,-1.75) L14(3.25,-1.75) M1(-3.25,-2.25) M2(-2.75,-2.25) M3(-2.25,-2.25) M4(-1.75,-2.25) M5(-1.25,-2.25) M6(-0.75,-2.25) M7(-0.25,-2.25) M8(0.25,-2.25) M9(0.75,-2.25) M10(1.25,-2.25) M11(1.75,-2.25) M12(2.25,-2.25) M13(2.75,-2.25) M14(3.25,-2.25) N1(-3.25,-2.75) N2(-2.75,-2.75) N3(-2.25,-2.75) N4(-1.75,-2.75) N5(-1.25,-2.75) N6(-0.75,-2.75) N7(-0.25,-2.75) N8(0.25,-2.75) N9(0.75,-2.75) N10(1.25,-2.75) N11(1.75,-2.75) N12(2.25,-2.75) N13(2.75,-2.75) N14(3.25,-2.75) P1(-3.25,-3.25) P2(-2.75,-3.25) P3(-2.25,-3.25) P4(-1.75,-3.25) P5(-1.25,-3.25) P6(-0.75,-3.25) P7(-0.25,-3.25) P8(0.25,-3.25) P9(0.75,-3.25) P10(1.25,-3.25) P11(1.75,-3.25) P12(2.25,-3.25) P13(2.75,-3.25) P14(3.25,-3.25)
FILTRER_COILCRAFT_0805
  rect 0.762x0.508 smd: 1(-0.838,-0.432) 2(0.838,-0.432) 3(0.838,0.432) 4(-0.838,0.432)
FUSE_1206
  rect 1.6x1.803 smd: 1(-1.4,0) 2(1.4,0)
HDR_1X4_100_640454-4_S_T
  rect 1.956x1.956 hole 1.27: 1(0,0)
  round 1.956 hole 1.27: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0)
HDR_2X1_100_S_T
  rect 1.778x1.778 hole 1.118: 1(0,0)
  round 1.778 hole 1.118: 2(-2.54,0)
HDR_2X25_100_S_T
  rect 1.727x1.727 hole 1.016: 1(0,0)
  round 1.727 hole 1.016: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54) 17(20.32,0) 18(20.32,2.54) 19(22.86,0) 20(22.86,2.54) 21(25.4,0) 22(25.4,2.54) 23(27.94,0) 24(27.94,2.54) 25(30.48,0) 26(30.48,2.54) 27(33.02,0) 28(33.02,2.54) 29(35.56,0) 30(35.56,2.54) 31(38.1,0) 32(38.1,2.54) 33(40.64,0) 34(40.64,2.54) 35(43.18,0) 36(43.18,2.54) 37(45.72,0) 38(45.72,2.54) 39(48.26,0) 40(48.26,2.54) 41(50.8,0) 42(50.8,2.54) 43(53.34,0) 44(53.34,2.54) 45(55.88,0) 46(55.88,2.54) 47(58.42,0) 48(58.42,2.54) 49(60.96,0) 50(60.96,2.54)
HDR_2X50_100_S_T
  rect 1.753x1.753 hole 1.067: 1(0,0)
  round 1.753 hole 1.067: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54) 17(20.32,0) 18(20.32,2.54) 19(22.86,0) 20(22.86,2.54) 21(25.4,0) 22(25.4,2.54) 23(27.94,0) 24(27.94,2.54) 25(30.48,0) 26(30.48,2.54) 27(33.02,0) 28(33.02,2.54) 29(35.56,0) 30(35.56,2.54) 31(38.1,0) 32(38.1,2.54) 33(40.64,0) 34(40.64,2.54) 35(43.18,0) 36(43.18,2.54) 37(45.72,0) 38(45.72,2.54) 39(48.26,0) 40(48.26,2.54) 41(50.8,0) 42(50.8,2.54) 43(53.34,0) 44(53.34,2.54) 45(55.88,0) 46(55.88,2.54) 47(58.42,0) 48(58.42,2.54) 49(60.96,0) 50(60.96,2.54) 51(63.5,0) 52(63.5,2.54) 53(66.04,0) 54(66.04,2.54) 55(68.58,0) 56(68.58,2.54) 57(71.12,0) 58(71.12,2.54) 59(73.66,0) 60(73.66,2.54) 61(76.2,0) 62(76.2,2.54) 63(78.74,0) 64(78.74,2.54) 65(81.28,0) 66(81.28,2.54) 67(83.82,0) 68(83.82,2.54) 69(86.36,0) 70(86.36,2.54) 71(88.9,0) 72(88.9,2.54) 73(91.44,0) 74(91.44,2.54) 75(93.98,0) 76(93.98,2.54) 77(96.52,0) 78(96.52,2.54) 79(99.06,0) 80(99.06,2.54) 81(101.6,0) 82(101.6,2.54) 83(104.14,0) 84(104.14,2.54) 85(106.68,0) 86(106.68,2.54) 87(109.22,0) 88(109.22,2.54) 89(111.76,0) 90(111.76,2.54) 91(114.3,0) 92(114.3,2.54) 93(116.84,0) 94(116.84,2.54) 95(119.38,0) 96(119.38,2.54) 97(121.92,0) 98(121.92,2.54) 99(124.46,0) 100(124.46,2.54)
HDR_3X1_100_S_T
  rect 1.778x1.778 hole 1.118: 1(0,0)
  round 1.778 hole 1.118: 2(-2.54,0) 3(-5.08,0)
HDR_5X1_100_S_T
  rect 1.778x1.778 hole 1.118: 1(0,0)
  round 1.778 hole 1.118: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0) 5(-10.16,0)
HDR_6X1_100_S_T
  rect 1.753x1.753 hole 1.118: 1(0,0)
  round 1.753 hole 1.118: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0) 5(-10.16,0) 6(-12.7,0)
HDR_7X2_100_S_T
  rect 1.753x1.753 hole 1.067: 1(0,0)
  round 1.753 hole 1.067: 2(0,-2.54) 3(-2.54,0) 4(-2.54,-2.54) 5(-5.08,0) 6(-5.08,-2.54) 7(-7.62,0) 8(-7.62,-2.54) 9(-10.16,0) 10(-10.16,-2.54) 11(-12.7,0) 12(-12.7,-2.54) 13(-15.24,0) 14(-15.24,-2.54)
IND0402
  rect 0.559x0.635 smd: 1(-0.475,0) 2(0.475,0)
IND0603
  rect 1.118x1.016 smd: 1(-0.85,0) 2(0.85,0)
IND1008
  rect 1.27x2.21 smd: 1(-1.15,0) 2(1.15,0)
IND_201209_90X60_SMD
  rect 1.016x1.016 smd: 1(-1,0) 2(1,0)
IND_B82476A_510X370_SMD
  rect 2.921x2.794 smd: 1(-5.146,0) 2(5.146,0)
IND_DR1040_415X405_SMD
  rect 1.6x3.2 smd: 1(-4.65,0) 2(4.65,0)
IND_PCMB104T_455X405_SMD
  rect 3.505x4.013 smd: 1(-3.997,0) 2(3.997,0)
IND_VLCF5020T_205X210_SMD
  rect 4.902x2.108 smd: 1(0,-1.7) 2(0,1.7)
IND_XAL7030_315X315_SMD
  rect 1.778x6.223 smd: 1(-2.36,0) 2(2.36,0)
LED_0805
  rect 1.321x1.524 smd: 1(-0.95,0) 2(0.95,0)
LFBGA96_31-49_220X540
  round 1.016 smd: (-3.937,-8.001) (3.937,8.001)
  round 0.457 smd: A1(-2,6) A2(-1.2,6) A3(-0.4,6) A4(0.4,6) A5(1.2,6) A6(2,6) B1(-2,5.2) B2(-1.2,5.2) B3(-0.4,5.2) B4(0.4,5.2) B5(1.2,5.2) B6(2,5.2) C1(-2,4.4) C2(-1.2,4.4) C3(-0.4,4.4) C4(0.4,4.4) C5(1.2,4.4) C6(2,4.4) D1(-2,3.6) D2(-1.2,3.6) D3(-0.4,3.6) D4(0.4,3.6) D5(1.2,3.6) D6(2,3.6) E1(-2,2.8) E2(-1.2,2.8) E3(-0.4,2.8) E4(0.4,2.8) E5(1.2,2.8) E6(2,2.8) F1(-2,2) F2(-1.2,2) F3(-0.4,2) F4(0.4,2) F5(1.2,2) F6(2,2) G1(-2,1.2) G2(-1.2,1.2) G3(-0.4,1.2) G4(0.4,1.2) G5(1.2,1.2) G6(2,1.2) H1(-2,0.4) H2(-1.2,0.4) H3(-0.4,0.4) H4(0.4,0.4) H5(1.2,0.4) H6(2,0.4) J1(-2,-0.4) J2(-1.2,-0.4) J3(-0.4,-0.4) J4(0.4,-0.4) J5(1.2,-0.4) J6(2,-0.4) K1(-2,-1.2) K2(-1.2,-1.2) K3(-0.4,-1.2) K4(0.4,-1.2) K5(1.2,-1.2) K6(2,-1.2) L1(-2,-2) L2(-1.2,-2) L3(-0.4,-2) L4(0.4,-2) L5(1.2,-2) L6(2,-2) M1(-2,-2.8) M2(-1.2,-2.8) M3(-0.4,-2.8) M4(0.4,-2.8) M5(1.2,-2.8) M6(2,-2.8) N1(-2,-3.6) N2(-1.2,-3.6) N3(-0.4,-3.6) N4(0.4,-3.6) N5(1.2,-3.6) N6(2,-3.6) P1(-2,-4.4) P2(-1.2,-4.4) P3(-0.4,-4.4) P4(0.4,-4.4) P5(1.2,-4.4) P6(2,-4.4) R1(-2,-5.2) R2(-1.2,-5.2) R3(-0.4,-5.2) R4(0.4,-5.2) R5(1.2,-5.2) R6(2,-5.2) T1(-2,-6) T2(-1.2,-6) T3(-0.4,-6) T4(0.4,-6) T5(1.2,-6) T6(2,-6)
MOD17_NHD-C12832A1Z
  round 0.94 hole 1.067 unplated: (-8.1,23.1) (-8.1,0) (32.1,23.1) (32.1,0)
  rect 1.067x1.067 hole 0.762: 1(0,0)
  round 1.219 hole 0.813: 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0) 13(18,0) 14(19.5,0) 15(21,0) 16(22.5,0) 17(24,0)
  round 2.464 hole 1.778: A(-5.3,1.95) K(29.3,1.95)
MSOP8_25-59_125X125
  rect 1.397x0.457 smd: 1(-2.2,0.975) 2(-2.2,0.325) 3(-2.2,-0.325) 4(-2.2,-0.975) 5(2.2,-0.975) 6(2.2,-0.325) 7(2.2,0.325) 8(2.2,0.975)
MSOP10_19-68_120X120
  rect 1.448x0.305 smd: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
NFBGA212_19-68_400X400
  round 1.016 smd: (-6.058,-6.058) (6.058,6.058)
  round 0.254 smd: A1(-4.5,4.5) A2(-4,4.5) A4(-3,4.5) A5(-2.5,4.5) A7(-1.5,4.5) A8(-1,4.5) A10(0,4.5) A11(0.5,4.5) A13(1.5,4.5) A14(2,4.5) A16(3,4.5) A17(3.5,4.5) A18(4,4.5) A19(4.5,4.5) B1(-4.5,4) B2(-4,4) B3(-3.5,4) B4(-3,4) B5(-2.5,4) B6(-2,4) B7(-1.5,4) B8(-1,4) B9(-0.5,4) B10(0,4) B11(0.5,4) B12(1,4) B13(1.5,4) B14(2,4) B15(2.5,4) B16(3,4) B17(3.5,4) B18(4,4) B19(4.5,4) C1(-4.5,3.5) C2(-4,3.5) C5(-2.5,3.5) C6(-2,3.5) C8(-1,3.5) C10(0,3.5) C12(1,3.5) C14(2,3.5) C15(2.5,3.5) C18(4,3.5) D1(-4.5,3) D2(-4,3) D6(-2,3) D7(-1.5,3) D8(-1,3) D12(1,3) D13(1.5,3) D14(2,3) D18(4,3) D19(4.5,3) E2(-4,2.5) E3(-3.5,2.5) E7(-1.5,2.5) E10(0,2.5) E13(1.5,2.5) E17(3.5,2.5) E18(4,2.5) E19(4.5,2.5) F1(-4.5,2) F2(-4,2) F3(-3.5,2) F4(-3,2) F10(0,2) F16(3,2) F17(3.5,2) F18(4,2) G1(-4.5,1.5) G2(-4,1.5) G4(-3,1.5) G5(-2.5,1.5) G10(0,1.5) G15(2.5,1.5) G16(3,1.5) G18(4,1.5) G19(4.5,1.5) H2(-4,1) H3(-3.5,1) H4(-3,1) H9(-0.5,1) H10(0,1) H11(0.5,1) H12(1,1) H16(3,1) H17(3.5,1) H18(4,1) H19(4.5,1) J1(-4.5,0.5) J2(-4,0.5) J8(-1,0.5) J9(-0.5,0.5) J10(0,0.5) J11(0.5,0.5) J12(1,0.5) J18(4,0.5) K1(-4.5,0) K2(-4,0) K3(-3.5,0) K5(-2.5,0) K6(-2,0) K7(-1.5,0) K8(-1,0) K9(-0.5,0) K10(0,0) K11(0.5,0) K12(1,0) K13(1.5,0) K14(2,0) K15(2.5,0) K17(3.5,0) K18(4,0) K19(4.5,0) L2(-4,-0.5) L8(-1,-0.5) L9(-0.5,-0.5) L10(0,-0.5) L11(0.5,-0.5) L12(1,-0.5) L18(4,-0.5) L19(4.5,-0.5) M1(-4.5,-1) M2(-4,-1) M3(-3.5,-1) M4(-3,-1) M8(-1,-1) M9(-0.5,-1) M10(0,-1) M11(0.5,-1) M12(1,-1) M16(3,-1) M17(3.5,-1) M18(4,-1) N1(-4.5,-1.5) N2(-4,-1.5) N4(-3,-1.5) N5(-2.5,-1.5) N10(0,-1.5) N15(2.5,-1.5) N16(3,-1.5) N18(4,-1.5) N19(4.5,-1.5) P2(-4,-2) P3(-3.5,-2) P4(-3,-2) P10(0,-2) P16(3,-2) P17(3.5,-2) P18(4,-2) P19(4.5,-2) R1(-4.5,-2.5) R2(-4,-2.5) R3(-3.5,-2.5) R7(-1.5,-2.5) R10(0,-2.5) R13(1.5,-2.5) R17(3.5,-2.5) R18(4,-2.5) T1(-4.5,-3) T2(-4,-3) T6(-2,-3) T7(-1.5,-3) T8(-1,-3) T12(1,-3) T13(1.5,-3) T14(2,-3) T18(4,-3) T19(4.5,-3) U2(-4,-3.5) U5(-2.5,-3.5) U6(-2,-3.5) U8(-1,-3.5) U10(0,-3.5) U12(1,-3.5) U14(2,-3.5) U15(2.5,-3.5) U18(4,-3.5) U19(4.5,-3.5) V1(-4.5,-4) V2(-4,-4) V3(-3.5,-4) V4(-3,-4) V5(-2.5,-4) V6(-2,-4) V7(-1.5,-4) V8(-1,-4) V9(-0.5,-4) V10(0,-4) V11(0.5,-4) V12(1,-4) V13(1.5,-4) V14(2,-4) V15(2.5,-4) V16(3,-4) V17(3.5,-4) V18(4,-4) V19(4.5,-4) W1(-4.5,-4.5) W2(-4,-4.5) W3(-3.5,-4.5) W4(-3,-4.5) W6(-2,-4.5) W7(-1.5,-4.5) W9(-0.5,-4.5) W10(0,-4.5) W12(1,-4.5) W13(1.5,-4.5) W15(2.5,-4.5) W16(3,-4.5) W18(4,-4.5) W19(4.5,-4.5)
OSC4_ASEK_130X110_SMD
  rect 1.397x1.143 smd: 1(-1.25,-1) 2(1.25,-1) 3(1.25,1) 4(-1.25,1)
OSC4_CB3_305X205_SMD
  rect 1.803x2.007 smd: 1(-2.54,-2.1) 2(2.54,-2.1) 3(2.54,2.1) 4(-2.54,2.1)
OSC10_E6718LF_280X200_SMD
  rect 0.813x2.54 smd: 1(-1.27,-2.285)
  rect 0.635x2.032 smd: 2(0,-2.54) 3(1.27,-2.54) 6(1.27,2.54) 7(0,2.54) 8(-1.27,2.54)
  rect 2.032x0.813 smd: 4(3.555,-1.27) 5(3.555,1.27) 9(-3.555,1.27) 10(-3.555,-1.27)
QFN10_15-74_75X60
  round 1.016 smd: (-1.905,1.651) (1.905,-1.651)
  rect 0.191x0.66 smd: 1(-0.2,-0.75) 2(0.2,-0.75) 6(0.2,0.75) 7(-0.2,0.75)
  rect 0.66x0.191 smd: 3(0.95,-0.4) 4(0.95,0) 5(0.95,0.4) 8(-0.95,0.4) 9(-0.95,0) 10(-0.95,-0.4)
QFN14_19-68_145X145
  rect 0.838x0.279 smd: 1(-1.725,-0.75) 7(1.725,-0.75) 8(1.725,0.75) 14(-1.725,0.75)
  rect 0.279x0.838 smd: 2(-1,-1.725) 3(-0.5,-1.725) 4(0,-1.725) 5(0.5,-1.725) 6(1,-1.725) 9(1,1.725) 10(0.5,1.725) 11(0,1.725) 12(-0.5,1.725) 13(-1,1.725)
  custom 0.512x0.512 smd: 15(0,0)
QFN16_19-68_120X120
  rect 0.864x0.305 smd: 1(-1.5,0.75) 2(-1.5,0.25) 3(-1.5,-0.25) 4(-1.5,-0.75) 9(1.5,-0.75) 10(1.5,-0.25) 11(1.5,0.25) 12(1.5,0.75)
  rect 0.305x0.864 smd: 5(-0.75,-1.5) 6(-0.25,-1.5) 7(0.25,-1.5) 8(0.75,-1.5) 13(0.75,1.5) 14(0.25,1.5) 15(-0.25,1.5) 16(-0.75,1.5)
  rect 1.549x1.549 smd: 17(0,0)
QFN16_25-59_160X160
  rect 0.813x0.356 smd: 1(-2,0.975) 2(-2,0.325) 3(-2,-0.325) 4(-2,-0.975) 9(2,-0.975) 10(2,-0.325) 11(2,0.325) 12(2,0.975)
  rect 0.356x0.813 smd: 5(-0.975,-2) 6(-0.325,-2) 7(0.325,-2) 8(0.975,-2) 13(0.975,2) 14(0.325,2) 15(-0.325,2) 16(-0.975,2)
  rect 2.794x2.794 smd: 17(0,0)
QFN24_19-68_160X160
  rect 0.864x0.305 smd: 1(-1.975,1.25) 2(-1.975,0.75) 3(-1.975,0.25) 4(-1.975,-0.25) 5(-1.975,-0.75) 6(-1.975,-1.25) 13(1.975,-1.25) 14(1.975,-0.75) 15(1.975,-0.25) 16(1.975,0.25) 17(1.975,0.75) 18(1.975,1.25)
  rect 0.305x0.864 smd: 7(-1.25,-1.975) 8(-0.75,-1.975) 9(-0.25,-1.975) 10(0.25,-1.975) 11(0.75,-1.975) 12(1.25,-1.975) 19(1.25,1.975) 20(0.75,1.975) 21(0.25,1.975) 22(-0.25,1.975) 23(-0.75,1.975) 24(-1.25,1.975)
  rect 2.718x2.718 smd: 25(0,0)
QFN24_19-68_165X165
  rect 0.864x0.305 smd: 1(-1.975,1.25) 2(-1.975,0.75) 3(-1.975,0.25) 4(-1.975,-0.25) 5(-1.975,-0.75) 6(-1.975,-1.25) 13(1.975,-1.25) 14(1.975,-0.75) 15(1.975,-0.25) 16(1.975,0.25) 17(1.975,0.75) 18(1.975,1.25)
  rect 0.305x0.864 smd: 7(-1.25,-1.975) 8(-0.75,-1.975) 9(-0.25,-1.975) 10(0.25,-1.975) 11(0.75,-1.975) 12(1.25,-1.975) 19(1.25,1.975) 20(0.75,1.975) 21(0.25,1.975) 22(-0.25,1.975) 23(-0.75,1.975) 24(-1.25,1.975)
  rect 2.718x2.718 smd: 25(0,0)
QFN24_19-68_225X145
  rect 0.914x0.254 smd: 1(-2.7,-0.75) 12(2.7,-0.75) 13(2.7,0.75) 24(-2.7,0.75)
  rect 0.254x0.914 smd: 2(-2.25,-1.7) 3(-1.75,-1.7) 4(-1.25,-1.7) 5(-0.75,-1.7) 6(-0.25,-1.7) 7(0.25,-1.7) 8(0.75,-1.7) 9(1.25,-1.7) 10(1.75,-1.7) 11(2.25,-1.7) 14(2.25,1.7) 15(1.75,1.7) 16(1.25,1.7) 17(0.75,1.7) 18(0.25,1.7) 19(-0.25,1.7) 20(-0.75,1.7) 21(-1.25,1.7) 22(-1.75,1.7) 23(-2.25,1.7)
  custom 0.508x0.508 smd: 25(0,0)
QFN48_19-68_280X280
  rect 0.635x0.279 smd: 1(-3.3,2.75) 2(-3.3,2.25) 3(-3.3,1.75) 4(-3.3,1.25) 5(-3.3,0.75) 6(-3.3,0.25) 7(-3.3,-0.25) 8(-3.3,-0.75) 9(-3.3,-1.25) 10(-3.3,-1.75) 11(-3.3,-2.25) 12(-3.3,-2.75) 25(3.3,-2.75) 26(3.3,-2.25) 27(3.3,-1.75) 28(3.3,-1.25) 29(3.3,-0.75) 30(3.3,-0.25) 31(3.3,0.25) 32(3.3,0.75) 33(3.3,1.25) 34(3.3,1.75) 35(3.3,2.25) 36(3.3,2.75)
  rect 0.279x0.635 smd: 13(-2.75,-3.3) 14(-2.25,-3.3) 15(-1.75,-3.3) 16(-1.25,-3.3) 17(-0.75,-3.3) 18(-0.25,-3.3) 19(0.25,-3.3) 20(0.75,-3.3) 21(1.25,-3.3) 22(1.75,-3.3) 23(2.25,-3.3) 24(2.75,-3.3) 37(2.75,3.3) 38(2.25,3.3) 39(1.75,3.3) 40(1.25,3.3) 41(0.75,3.3) 42(0.25,3.3) 43(-0.25,3.3) 44(-0.75,3.3) 45(-1.25,3.3) 46(-1.75,3.3) 47(-2.25,3.3) 48(-2.75,3.3)
  rect 5.055x5.055 smd: 49(0,0)
QFN72_19-68_395X395
  round 1.016 smd: (-5.715,5.715) (5.715,-5.715)
  rect 0.965x0.279 smd: 1(-5.027,4.25) 2(-5.027,3.75) 3(-5.027,3.25) 4(-5.027,2.75) 5(-5.027,2.25) 6(-5.027,1.75) 7(-5.027,1.25) 8(-5.027,0.75) 9(-5.027,0.25) 10(-5.027,-0.25) 11(-5.027,-0.75) 12(-5.027,-1.25) 13(-5.027,-1.75) 14(-5.027,-2.25) 15(-5.027,-2.75) 16(-5.027,-3.25) 17(-5.027,-3.75) 18(-5.027,-4.25) 37(5.027,-4.25) 38(5.027,-3.75) 39(5.027,-3.25) 40(5.027,-2.75) 41(5.027,-2.25) 42(5.027,-1.75) 43(5.027,-1.25) 44(5.027,-0.75) 45(5.027,-0.25) 46(5.027,0.25) 47(5.027,0.75) 48(5.027,1.25) 49(5.027,1.75) 50(5.027,2.25) 51(5.027,2.75) 52(5.027,3.25) 53(5.027,3.75) 54(5.027,4.25)
  rect 0.279x0.965 smd: 19(-4.25,-5.027) 20(-3.75,-5.027) 21(-3.25,-5.027) 22(-2.75,-5.027) 23(-2.25,-5.027) 24(-1.75,-5.027) 25(-1.25,-5.027) 26(-0.75,-5.027) 27(-0.25,-5.027) 28(0.25,-5.027) 29(0.75,-5.027) 30(1.25,-5.027) 31(1.75,-5.027) 32(2.25,-5.027) 33(2.75,-5.027) 34(3.25,-5.027) 35(3.75,-5.027) 36(4.25,-5.027) 55(4.25,5.027) 56(3.75,5.027) 57(3.25,5.027) 58(2.75,5.027) 59(2.25,5.027) 60(1.75,5.027) 61(1.25,5.027) 62(0.75,5.027) 63(0.25,5.027) 64(-0.25,5.027) 65(-0.75,5.027) 66(-1.25,5.027) 67(-1.75,5.027) 68(-2.25,5.027) 69(-2.75,5.027) 70(-3.25,5.027) 71(-3.75,5.027) 72(-4.25,5.027)
  rect 4.953x4.953 smd: 73(0,0)
RES0201
  rect 0.457x0.432 smd: 1(-0.33,0) 2(0.33,0)
RES0402
  rect 0.914x0.711 smd: 1(-0.65,0) 2(0.65,0)
RES0603
  rect 1.118x1.016 smd: 1(-0.85,0) 2(0.85,0)
RES0805
  rect 1.194x1.448 smd: 1(-0.95,0) 2(0.95,0)
RES1206
  rect 1.067x1.753 smd: 1(-1.45,0) 2(1.45,0)
RES1210
  rect 1.6x2.718 smd: 1(-1.4,0) 2(1.4,0)
RES1812
  rect 1.905x3.404 smd: 1(-1.95,0) 2(1.95,0)
RES2725
  rect 2.845x6.96 smd: 1(-2.45,0) 2(2.45,0)
RESA_0402-4
  rect 0.533x0.508 smd: 1(-0.902,-0.454) 4(0.902,-0.454) 5(0.902,0.454) 8(-0.902,0.454)
  rect 0.254x0.508 smd: 2(-0.254,-0.454) 3(0.254,-0.454) 6(0.254,0.454) 7(-0.254,0.454)
RESA_0402-8
  rect 0.406x0.635 smd: 1(-1.813,-0.75) 8(1.813,-0.75) 9(1.813,0.75) 16(-1.813,0.75)
  rect 0.279x0.635 smd: 2(-1.25,-0.75) 3(-0.75,-0.75) 4(-0.25,-0.75) 5(0.25,-0.75) 6(0.75,-0.75) 7(1.25,-0.75) 10(1.25,0.75) 11(0.75,0.75) 12(0.25,0.75) 13(-0.25,0.75) 14(-0.75,0.75) 15(-1.25,0.75)
SC70-5
  rect 0.406x1.321 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(-0.65,0.95)
SC70-6
  rect 0.864x0.356 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0) 6(1.1,0.65)
SMD10_R1Z_600X420
  rect 1.219x1.803 smd: 1(-5.08,-5.1) 2(-2.54,-5.1) 4(2.54,-5.1) 5(5.08,-5.1) 7(2.54,5.1) 10(-5.08,5.1)
SOIC8
  rect 2.21x0.61 smd: 1(-2.6,1.905) 2(-2.6,0.635) 3(-2.6,-0.635) 4(-2.6,-1.905) 5(2.6,-1.905) 6(2.6,-0.635) 7(2.6,0.635) 8(2.6,1.905)
SOIC16
  rect 1.93x0.66 smd: 1(-3.625,4.445) 2(-3.625,3.175) 3(-3.625,1.905) 4(-3.625,0.635) 5(-3.625,-0.635) 6(-3.625,-1.905) 7(-3.625,-3.175) 8(-3.625,-4.445) 9(3.625,-4.445) 10(3.625,-3.175) 11(3.625,-1.905) 12(3.625,-0.635) 13(3.625,0.635) 14(3.625,1.905) 15(3.625,3.175) 16(3.625,4.445)
SOIC16_W
  rect 2.007x0.61 smd: 1(-4.65,4.445) 2(-4.65,3.175) 3(-4.65,1.905) 4(-4.65,0.635) 5(-4.65,-0.635) 6(-4.65,-1.905) 7(-4.65,-3.175) 8(-4.65,-4.445) 9(4.65,-4.445) 10(4.65,-3.175) 11(4.65,-1.905) 12(4.65,-0.635) 13(4.65,0.635) 14(4.65,1.905) 15(4.65,3.175) 16(4.65,4.445)
SON6_19-68_60X45
  rect 0.305x0.508 smd: 1(-0.5,-0.385) 2(0,-0.385) 3(0.5,-0.385) 4(0.5,0.385) 5(0,0.385) 6(-0.5,0.385)
SON8_25-59_130X130
  rect 0.864x0.356 smd: 1(-1.499,0.975) 2(-1.499,0.325) 3(-1.499,-0.325) 4(-1.499,-0.975) 5(1.499,-0.975) 6(1.499,-0.325) 7(1.499,0.325) 8(1.499,0.975)
  rect 1.727x2.438 smd: 9(0,0)
SON8_25-59_130X130_TI
  rect 0.66x1.092 smd: 1(-1.475,0.65)
  rect 0.66x0.432 smd: 3(-1.475,-0.325) 4(-1.475,-0.975) 5(1.475,-0.975) 6(1.475,-0.325) 7(1.475,0.325) 8(1.475,0.975)
  custom 0.475x0.475 smd: 9(0,0)
SON10_19-68_130X130
  rect 0.864x0.279 smd: 1(-1.55,1) 2(-1.55,0.5) 3(-1.55,0) 4(-1.55,-0.5) 5(-1.55,-1) 6(1.55,-1) 7(1.55,-0.5) 8(1.55,0) 9(1.55,0.5) 10(1.55,1)
  rect 1.473x3.81 smd: 11(0,0)
SOP8_100_375X260
  rect 2.362x0.66 smd: 1(-4.55,3.81) 2(-4.55,1.27) 3(-4.55,-1.27) 4(-4.55,-3.81) 5(4.55,-3.81) 6(4.55,-1.27) 7(4.55,1.27) 8(4.55,3.81)
SOT23-5
  rect 0.66x1.321 smd: 1(-0.95,-1.25) 2(0,-1.25) 3(0.95,-1.25) 4(0.95,1.25) 5(-0.95,1.25)
SOT23-6
  rect 1.041x0.61 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0) 6(1.35,0.95)
SOT23-123
  rect 0.787x0.889 smd: 1(-0.95,-1) 2(0.95,-1) 3(0,1)
SOT223-3
  rect 1.219x2.21 smd: 1(-2.3,-3.1) 2(0,-3.1) 3(2.3,-3.1)
  rect 3.607x2.21 smd: 4(0,3.1)
SOT533-5
  rect 0.279x1.067 smd: 1(-0.5,-0.75) 2(0,-0.75) 3(0.5,-0.75) 4(0.5,0.75) 5(-0.5,0.75)
SOT563-6
  rect 0.279x0.508 smd: 1(-0.5,-0.85) 2(0,-0.85) 3(0.5,-0.85) 4(0.5,0.85) 5(0,0.85) 6(-0.5,0.85)
SOT-3
  rect 0.305x0.305 smd: 1(-0.52,0.35) 2(-0.52,-0.35) 3(0.33,0)
SW2_100X324-80_180X300_SMD
  rect 1.499x2.159 smd: 1(0,4.125) 2(0,-4.125)
SW3_100_400X200_TH
  rect 1.753x1.753 hole 1.118: 1(0,0)
  round 1.753 hole 1.118: 2(2.54,0) 3(5.08,0)
SW4_EVQQ2_255X240_SMD
  rect 3.2x1.016 smd: 1(-3.404,2) 2(3.404,2) 3(-3.404,-2) 4(3.404,-2)
SW8_GDH04S04_265X245
  rect 0.762x1.27 smd: 1(-1.905,-3.797) 2(-0.635,-3.797) 3(0.635,-3.797) 4(1.905,-3.797) 5(1.905,3.797) 6(0.635,3.797) 7(-0.635,3.797) 8(-1.905,3.797)
TO_SOT23-123
  rect 1.016x1.397 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
TP20_SMD
  round 0.508 smd: 1(0,0)
TP40_SMD
  round 1.016 smd: 1(0,0)
TP_40X65
  round 1.651 hole 1.016: 1(0,0)
TP_40X80
  round 2.032 hole 1.016: 1(0,0)
TQFP44_31-49_400X400
  round 1.016 smd: (-5.7,-5.7) (5.7,5.7)
  rect 1.499x0.559 smd: 1(-5.7,4) 2(-5.7,3.2) 3(-5.7,2.4) 4(-5.7,1.6) 5(-5.7,0.8) 6(-5.7,0) 7(-5.7,-0.8) 8(-5.7,-1.6) 9(-5.7,-2.4) 10(-5.7,-3.2) 11(-5.7,-4) 23(5.7,-4) 24(5.7,-3.2) 25(5.7,-2.4) 26(5.7,-1.6) 27(5.7,-0.8) 28(5.7,0) 29(5.7,0.8) 30(5.7,1.6) 31(5.7,2.4) 32(5.7,3.2) 33(5.7,4)
  rect 0.559x1.499 smd: 12(-4,-5.7) 13(-3.2,-5.7) 14(-2.4,-5.7) 15(-1.6,-5.7) 16(-0.8,-5.7) 17(0,-5.7) 18(0.8,-5.7) 19(1.6,-5.7) 20(2.4,-5.7) 21(3.2,-5.7) 22(4,-5.7) 34(4,5.7) 35(3.2,5.7) 36(2.4,5.7) 37(1.6,5.7) 38(0.8,5.7) 39(0,5.7) 40(-0.8,5.7) 41(-1.6,5.7) 42(-2.4,5.7) 43(-3.2,5.7) 44(-4,5.7)
TSOP48_19-68_730X480
  round 1.016 smd: (-9.8,-7.112) (9.8,7.112)
  rect 1.295x0.305 smd: 1(-9.8,5.75) 2(-9.8,5.25) 3(-9.8,4.75) 4(-9.8,4.25) 5(-9.8,3.75) 6(-9.8,3.25) 7(-9.8,2.75) 8(-9.8,2.25) 9(-9.8,1.75) 10(-9.8,1.25) 11(-9.8,0.75) 12(-9.8,0.25) 13(-9.8,-0.25) 14(-9.8,-0.75) 15(-9.8,-1.25) 16(-9.8,-1.75) 17(-9.8,-2.25) 18(-9.8,-2.75) 19(-9.8,-3.25) 20(-9.8,-3.75) 21(-9.8,-4.25) 22(-9.8,-4.75) 23(-9.8,-5.25) 24(-9.8,-5.75) 25(9.8,-5.75) 26(9.8,-5.25) 27(9.8,-4.75) 28(9.8,-4.25) 29(9.8,-3.75) 30(9.8,-3.25) 31(9.8,-2.75) 32(9.8,-2.25) 33(9.8,-1.75) 34(9.8,-1.25) 35(9.8,-0.75) 36(9.8,-0.25) 37(9.8,0.25) 38(9.8,0.75) 39(9.8,1.25) 40(9.8,1.75) 41(9.8,2.25) 42(9.8,2.75) 43(9.8,3.25) 44(9.8,3.75) 45(9.8,4.25) 46(9.8,4.75) 47(9.8,5.25) 48(9.8,5.75)
TSSOP8_25-59_125X180
  rect 1.702x0.406 smd: 1(-2.85,0.975) 2(-2.85,0.325) 3(-2.85,-0.325) 4(-2.85,-0.975) 5(2.85,-0.975) 6(2.85,-0.325) 7(2.85,0.325) 8(2.85,0.975)
TSSOP16_25-59_205X180
  rect 1.6x0.356 smd: 1(-2.8,2.275) 2(-2.8,1.625) 3(-2.8,0.975) 4(-2.8,0.325) 5(-2.8,-0.325) 6(-2.8,-0.975) 7(-2.8,-1.625) 8(-2.8,-2.275) 9(2.8,-2.275) 10(2.8,-1.625) 11(2.8,-0.975) 12(2.8,-0.325) 13(2.8,0.325) 14(2.8,0.975) 15(2.8,1.625) 16(2.8,2.275)
TSSOP20_25-59_260X180
  rect 1.702x0.406 smd: 1(-2.85,2.925) 2(-2.85,2.275) 3(-2.85,1.625) 4(-2.85,0.975) 5(-2.85,0.325) 6(-2.85,-0.325) 7(-2.85,-0.975) 8(-2.85,-1.625) 9(-2.85,-2.275) 10(-2.85,-2.925) 11(2.85,-2.925) 12(2.85,-2.275) 13(2.85,-1.625) 14(2.85,-0.975) 15(2.85,-0.325) 16(2.85,0.325) 17(2.85,0.975) 18(2.85,1.625) 19(2.85,2.275) 20(2.85,2.925)
TSSOP24_25-59_315X180
  rect 1.702x0.406 smd: 1(-2.85,3.575) 2(-2.85,2.925) 3(-2.85,2.275) 4(-2.85,1.625) 5(-2.85,0.975) 6(-2.85,0.325) 7(-2.85,-0.325) 8(-2.85,-0.975) 9(-2.85,-1.625) 10(-2.85,-2.275) 11(-2.85,-2.925) 12(-2.85,-3.575) 13(2.85,-3.575) 14(2.85,-2.925) 15(2.85,-2.275) 16(2.85,-1.625) 17(2.85,-0.975) 18(2.85,-0.325) 19(2.85,0.325) 20(2.85,0.975) 21(2.85,1.625) 22(2.85,2.275) 23(2.85,2.925) 24(2.85,3.575)
TVSOP48_15-74_385X180
  round 1.016 smd: (-2.85,6.124) (2.85,-6.124)
  rect 1.702x0.191 smd: 1(-2.85,4.6) 2(-2.85,4.2) 3(-2.85,3.8) 4(-2.85,3.4) 5(-2.85,3) 6(-2.85,2.6) 7(-2.85,2.2) 8(-2.85,1.8) 9(-2.85,1.4) 10(-2.85,1) 11(-2.85,0.6) 12(-2.85,0.2) 13(-2.85,-0.2) 14(-2.85,-0.6) 15(-2.85,-1) 16(-2.85,-1.4) 17(-2.85,-1.8) 18(-2.85,-2.2) 19(-2.85,-2.6) 20(-2.85,-3) 21(-2.85,-3.4) 22(-2.85,-3.8) 23(-2.85,-4.2) 24(-2.85,-4.6) 25(2.85,-4.6) 26(2.85,-4.2) 27(2.85,-3.8) 28(2.85,-3.4) 29(2.85,-3) 30(2.85,-2.6) 31(2.85,-2.2) 32(2.85,-1.8) 33(2.85,-1.4) 34(2.85,-1) 35(2.85,-0.6) 36(2.85,-0.2) 37(2.85,0.2) 38(2.85,0.6) 39(2.85,1) 40(2.85,1.4) 41(2.85,1.8) 42(2.85,2.2) 43(2.85,2.6) 44(2.85,3) 45(2.85,3.4) 46(2.85,3.8) 47(2.85,4.2) 48(2.85,4.6)
unnamed
  round 1.016 smd: (0,0)
unnamed#3
  round 6.401 hole 3.2: 1(0,0)
UQFN10_19-68_80X60
  rect 0.584x0.305 smd: 1(-0.635,0.75) 4(-0.635,-0.75) 6(0.635,-0.75) 9(0.635,0.75)
  rect 0.584x0.254 smd: 2(-0.637,0.25) 3(-0.637,-0.25) 7(0.637,-0.25) 8(0.637,0.25)
  rect 0.305x0.635 smd: 5(0,-0.86) 10(0,0.86)
USON10_19-68_40X100
  rect 0.559x0.305 smd: 1(-0.385,1) 2(-0.385,0.5) 4(-0.385,-0.5) 5(-0.385,-1) 6(0.385,-1) 7(0.385,-0.5) 9(0.385,0.5) 10(0.385,1)
  rect 0.559x0.406 smd: 3(-0.385,0) 8(0.385,0)
VAR0603
  rect 1.118x1.016 smd: 1(-0.85,0) 2(0.85,0)
VFBGA54_31-49_320X320
  round 1.016 smd: (-4.826,-4.826) (4.826,4.826)
  round 0.406 smd: A1(-3.2,3.2) A2(-2.4,3.2) A3(-1.6,3.2) A7(1.6,3.2) A8(2.4,3.2) A9(3.2,3.2) B1(-3.2,2.4) B2(-2.4,2.4) B3(-1.6,2.4) B7(1.6,2.4) B8(2.4,2.4) B9(3.2,2.4) C1(-3.2,1.6) C2(-2.4,1.6) C3(-1.6,1.6) C7(1.6,1.6) C8(2.4,1.6) C9(3.2,1.6) D1(-3.2,0.8) D2(-2.4,0.8) D3(-1.6,0.8) D7(1.6,0.8) D8(2.4,0.8) D9(3.2,0.8) E1(-3.2,0) E2(-2.4,0) E3(-1.6,0) E7(1.6,0) E8(2.4,0) E9(3.2,0) F1(-3.2,-0.8) F2(-2.4,-0.8) F3(-1.6,-0.8) F7(1.6,-0.8) F8(2.4,-0.8) F9(3.2,-0.8) G1(-3.2,-1.6) G2(-2.4,-1.6) G3(-1.6,-1.6) G7(1.6,-1.6) G8(2.4,-1.6) G9(3.2,-1.6) H1(-3.2,-2.4) H2(-2.4,-2.4) H3(-1.6,-2.4) H7(1.6,-2.4) H8(2.4,-2.4) H9(3.2,-2.4) J1(-3.2,-3.2) J2(-2.4,-3.2) J3(-1.6,-3.2) J7(1.6,-3.2) J8(2.4,-3.2) J9(3.2,-3.2)
VQFN48_19-68_285X285
  rect 0.838x0.279 smd: 1(-3.475,2.75) 2(-3.475,2.25) 3(-3.475,1.75) 4(-3.475,1.25) 5(-3.475,0.75) 6(-3.475,0.25) 7(-3.475,-0.25) 8(-3.475,-0.75) 9(-3.475,-1.25) 10(-3.475,-1.75) 11(-3.475,-2.25) 12(-3.475,-2.75) 25(3.475,-2.75) 26(3.475,-2.25) 27(3.475,-1.75) 28(3.475,-1.25) 29(3.475,-0.75) 30(3.475,-0.25) 31(3.475,0.25) 32(3.475,0.75) 33(3.475,1.25) 34(3.475,1.75) 35(3.475,2.25) 36(3.475,2.75)
  rect 0.279x0.838 smd: 13(-2.75,-3.475) 14(-2.25,-3.475) 15(-1.75,-3.475) 16(-1.25,-3.475) 17(-0.75,-3.475) 18(-0.25,-3.475) 19(0.25,-3.475) 20(0.75,-3.475) 21(1.25,-3.475) 22(1.75,-3.475) 23(2.25,-3.475) 24(2.75,-3.475) 37(2.75,3.475) 38(2.25,3.475) 39(1.75,3.475) 40(1.25,3.475) 41(0.75,3.475) 42(0.25,3.475) 43(-0.25,3.475) 44(-0.75,3.475) 45(-1.25,3.475) 46(-1.75,3.475) 47(-2.25,3.475) 48(-2.75,3.475)
  rect 5.156x5.156 smd: 49(0,0)
VSSOP8_25-59_120X120
  rect 1.651x0.457 smd: 1(-2.3,0.975) 2(-2.3,0.325) 3(-2.3,-0.325) 4(-2.3,-0.975) 5(2.3,-0.975) 6(2.3,-0.325) 7(2.3,0.325) 8(2.3,0.975)
XTAL2_ATS-SM_460X190_SMD
  rect 5.512x1.499 smd: 1(-4.25,0) 2(4.25,0)
XTAL4_86-61X62-99_130X105_SMD
  rect 1.422x1.219 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTAL4_ABM8G_130X105_SMD
  rect 1.397x1.194 smd: 1(-1.1,-0.851) 2(1.1,-0.851) 3(1.1,0.851) 4(-1.1,0.851)
XTAL4_NX3225GA_130X100_SMD
  rect 1.422x1.219 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTAL_ABM3_205X130_SMD
  rect 1.803x2.413 smd: 1(-1.9,0) 2(1.9,0)
XTAL_FC-135_130X65_SMD
  rect 1.016x1.803 smd: 1(-1.25,0) 2(1.25,0)

## Nets
3V3_CONN_FB: C104.2 R824.2 R825.2 U116.1(VFB)
3V3_CONN_PG: R852.2 TP55.1(TP) U20.U15(PQ6/EN0RXD1/U1DTR) U116.5(PG)
3V3_DCIN_FB: C806.2 R898.2 R899.2 U141.1(VFB)
3V3_DCIN_PG: R893.2 TP200.1(TP) U20.W12(PQ5/EN0RXD0/U1TX) U141.5(PG)
5V_EN: J46.2 U18.10(EN) U20.M1(PC5/C1+/EPI0S6/RTCCLK/T7CCP1/U7)
5V_PWRGD: R150.1 R908.2 R909.2 TP52.1(TP) U18.14(PWRGD) U20.B8(PP6/AIN23/I2C2SDA/U1DCD)
AGND: C116.2 C121.1 C151.1 C152.1 C157.2 C158.2 C160.2 C161.1 C163.2 C164.1 C457.2 C466.1 C469.2 C476.1 C504.1 C505.2 FB15.2 U32.D6(AGND_A) U32.E5(AGND_C) U32.E6(AGND_B) U32.F5(AGND_D) U32.G4(AGND_E) U32.H5(AGND_K) U32.H6(AGND_F) U32.J3(AGND_G) U32.J4(AGND_H) U32.J6(AGND_I) U32.K3(AGND_J) U32.M8(AGND2_B) U32.N8(AGND2_A)
AGND_XTAL: C127.1 C132.1 C472.1 FB13.1 U32.G7(REFGND)
AVDDA_ARMPLL: C174.2 C180.1 C525.2 FB17.2 U1.N6(AVDDA_ARMPLL)
AVDDA_DDRPLL: C258.1 C259.2 C623.2 FB27.2 U1.W20(AVDDA_DDRPLL)
AVDDA_DSSPLL: C249.1 C260.2 C625.2 FB29.2 U1.N20(AVDDA_DSSPLL)
AVDDA_ICSSPLL: C210.1 C211.1 C577.1 FB23.2 U1.G8(AVDDA_ICSSPLL)
AVDDA_MAINPLL: C250.1 C261.2 C624.2 FB28.2 U1.M19(AVDDA_MAINPLL)
AVDDA_NSSPLL: C219.1 C221.1 C594.1 FB25.2 U1.G14(AVDDA_NSSPLL)
AVDDA_UARTPLL: C217.1 C218.1 C592.1 FB24.2 U1.G10(AVDDA_UARTPLL)
