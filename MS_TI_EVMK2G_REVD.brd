# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_I2CSCL: length 26.1
  TOP w0.127: U108.2 91.35,27.61 v2(92,28.26) ; R562.2 99.64,45.38 99.21,44.95 v2(98.92,44.95) 99.42,44.45 U102.49
  L03_SIG1 w0.127: v2(92,28.26) 92,38.03 v2(98.92,44.95)
HDMI_I2CSDA: length 29.8
  TOP w0.127: U102.48 v2(99.92,44.06) ; U108.3 v2(90.7,27.25)
  L03_SIG1 w0.127: v2(90.7,27.25) 91.37,26.58 92.41,26.58 93.22,27.4 93.22,29.1 96.39,32.27 96.39,39.64 99.92,43.16 v2(99.92,44.06)
  BOTTOM w0.127: v2(99.92,44.06) 99.39,44.59 99.39,46.47 99.63,46.71 R769.2
HDMI_INTN: length 190.7
  TOP w0.127: 96.87,45.95 96.87,45.14 97.92,44.08 U102.52 ; 96.87,45.95 96.87,48.27 97.03,48.44 v2(97.03,49.52) ; 96.87,45.95 R556.2 ; v2(146.81,68.85) 146.81,71.24 150.39,74.82 v2(177.57,74.82) ; v1(185.8,116.6) 185.55,116.6 184.96,117.19 183.82,117.19 183.59,117.41 U1.A15
  L03_SIG1 w0.127: v2(146.81,68.85) 146.1,68.85 143.94,66.69 143.94,55.44 139.45,50.94 139.45,40.96 137.92,39.44 v2(122.83,39.44)
  L08_SIG2 w0.127: v2(122.83,39.44) 116.74,39.44 107.85,48.33 101.17,48.33 99.97,49.52 v2(97.03,49.52)
  BOTTOM w0.102: v1(185.8,116.6) 185.82,116.62 189.1,116.62
  BOTTOM w0.127: v2(177.57,74.82) 178.47,74.82 187.29,83.63 193.27,83.63 195.35,85.71 195.35,92.72 194.56,93.51 194.56,94.41 196.62,96.47 196.62,104.31 199.01,106.69 199.01,110.4 198.15,111.27 195.07,111.27 194.24,112.1 194.24,112.12 193.6,112.75 191.01,112.75 190.65,113.11 190.65,115.84 190.19,116.31 190.18,116.31 189.86,116.62 189.1,116.62
HDMI_PCLK: length 87.3
  TOP w0.127: U82.E2 v1(135.25,65.72) ; U102.22 v2(107.39,35.09)
  L03_SIG1 w0.127: v2(126.67,51.7) 125.49,50.52 125.49,49.25 122.99,46.75 121.84,46.75 121.72,46.88 121.72,47.3 121.84,47.43 122.68,47.43 122.81,47.56 122.81,47.81 122.68,47.94 121.84,47.94 121.72,48.06 121.72,48.39 121.59,48.52 121.33,48.52 121.21,48.39 121.21,45.73 121.08,45.61 120.83,45.61 120.7,45.73 120.7,48.39 120.57,48.52 120.32,48.52 120.19,48.39 120.19,47.98 120.06,47.86 119.65,47.86 119.52,47.73 119.52,47.47 119.65,47.35 120.06,47.35 120.19,47.22 120.19,46.88 120.06,46.75 119.63,46.75 118.69,47.69 118.51,47.69 118.06,47.24 117.88,47.24 117.7,47.42 117.7,47.6 118.15,48.05 118.15,48.23 117.91,48.48 114.15,48.48 112.32,46.65 112.32,43.69 110.73,42.1 108.71,42.1 106.68,40.07 106.68,37.99 106.55,37.87 105.19,37.87 105.07,37.74 105.07,37.49 105.19,37.36 106.55,37.36 106.68,37.23 106.68,36.98 106.55,36.85 105.19,36.85 105.07,36.72 105.07,36.47 105.19,36.34 106.55,36.34 106.68,36.22 106.68,35.33 106.92,35.09 v2(107.39,35.09)
  L08_SIG2 w0.127: v1(135.25,65.72) 135.25,65.93 135.65,66.32 135.65,66.68 135.64,66.69 136.14,67.2 140.72,67.2 141.73,66.18 141.73,60.9 134.69,53.85 134.49,53.85 134,53.36 134,53.29 132.16,51.45 127.03,51.45 126.77,51.7 v2(126.67,51.7)
HDMI_RSTN: length 176.9
  TOP w0.127: U91.1 115.2,54.69 110.69,59.2 v2(90.93,59.2) ; R274.1 87.36,176.02 87.25,175.91 v2(87.25,174.88) 88.53,174.88 89.42,173.99 U35.20
  BOTTOM w0.127: v2(90.93,59.2) 90.35,58.61 78.62,58.61 75.07,62.16 75.07,114.6 64.76,124.91 64.76,141.9 85.85,163 85.85,173.04 87.25,174.44 v2(87.25,174.88)
HDMI_RSTN_AND: length 26.4
  TOP w0.127: U91.4 v2(113.3,49.87) ; U102.51 98.42,44.14 97.92,44.64 v2(97.92,44.95)
  L08_SIG2 w0.127: v2(113.3,49.87) 112.71,49.28 101.97,49.28 101.09,50.15 96.93,50.15 96.44,49.67 96.44,48.81 97.92,47.33 v2(97.92,44.95)
HDMI_TX0+: length 32
  TOP w0.102: U102.62 95.51,38.59 95.41,38.68 94.75,38.68 94.65,38.58 94.65,38.42 94.55,38.32 94.35,38.32 94.25,38.42 94.25,38.58 94.14,38.68 93.77,38.68 91.24,36.15 91.24,31.88 93.99,29.13 93.99,24.01 93.17,23.19 90.34,23.19 89.99,22.84 89.62,22.47 88.91,22.47 88.01,21.57 88.01,21.08 88.1,20.99 U108.18 88.1,19.06 88.01,18.97 88.01,18.23 88.5,17.73 J36.7
HDMI_TX0-: length 32
  TOP w0.102: U102.61 95.47,39.09 95.39,39.01 93.64,39.01 90.91,36.28 90.91,31.75 93.66,28.99 93.66,24.14 93.04,23.52 90.2,23.52 89.66,22.97 89.48,22.8 88.77,22.8 87.68,21.71 87.68,21.12 87.45,20.9 U108.17 87.45,19.04 87.68,18.81 87.68,17.97 87.5,17.8 J36.9
HDMI_TX1+: length 29.2
  TOP w0.102: U102.65 95.51,37.09 95.41,37.18 94.85,37.18 94.75,37.08 94.75,36.92 94.65,36.82 94.45,36.82 94.35,36.92 94.35,37.08 94.24,37.18 93.92,37.18 92.2,35.46 92.2,32.29 94.94,29.54 94.94,23.61 93.57,22.24 90.73,22.24 89.88,21.39 89.88,21.17 90.05,21 U108.21 90.04,19.99 90.04,19.06 89.79,18.81 89.79,18.18 90,17.96 J36.4
HDMI_TX1-: length 29.3
  TOP w0.102: J36.6 89,17.77 89.46,18.23 89.46,18.92 89.41,18.97 89.41,19 89.4,19 U108.20 89.4,20.98 89.55,21.12 89.55,21.53 90.59,22.57 93.44,22.57 94.61,23.74 94.61,29.41 91.87,32.15 91.87,35.59 93.79,37.51 95.33,37.51 95.41,37.59 U102.64
HDMI_TX2+: length 27.3
  TOP w0.102: J36.1 91.5,17.73 91.14,18.1 91.14,18.76 91.35,18.98 U108.23 91.35,20.84 91.24,20.96 91.24,20.99 91.19,21.04 91.19,21.18 91.3,21.29 92.59,21.29 92.69,21.19 92.69,21.02 92.79,20.92 93,20.92 93.1,21.02 93.1,21.19 93.2,21.29 94.1,21.29 96.01,23.21 96.01,29.81 93.19,32.63 93.19,34.92 93.95,35.68 95.41,35.68 95.48,35.62 96.11,35.62 U102.68
HDMI_TX2-: length 27.2
  TOP w0.102: U102.67 95.27,36.09 95.2,36.01 93.81,36.01 92.86,35.06 92.86,32.5 95.68,29.67 95.68,23.34 93.96,21.62 91.17,21.62 90.86,21.31 90.86,21.05 90.7,20.89 U108.22 90.7,19 90.81,18.9 90.81,18.21 90.5,17.91 J36.3
HDMI_VSYNC: length 87
  TOP w0.127: v2(108.92,44.33) 108.92,43.02 107.48,41.59 U102.35 ; U82.F2 v1(134.45,65.72)
  L03_SIG1 w0.127: v2(108.92,44.33) 108.92,43.87 109.44,43.34 110.29,43.34 111,44.04 111,48.3 113.49,50.79 123.67,50.79 124.08,51.2 124.74,51.2 125.63,52.08 125.63,52.67 126.54,53.58 127.89,53.58 128.27,53.2 128.27,52.03 v2(126.67,50.43)
  L08_SIG2 w0.127: v1(134.45,65.72) 134.86,66.12 134.86,67.11 137.11,69.36 137.37,69.36 137.49,69.23 137.49,68.85 137.62,68.72 137.87,68.72 138,68.85 138,69.23 138.13,69.36 138.38,69.36 138.51,69.23 138.51,68.85 138.64,68.72 138.89,68.72 139.02,68.85 139.02,69.23 139.14,69.36 139.4,69.36 139.53,69.23 139.53,68.85 139.65,68.72 139.91,68.72 140.03,68.85 140.03,69.23 140.16,69.36 140.41,69.36 140.54,69.23 140.54,68.85 140.67,68.72 140.92,68.72 141.05,68.85 141.05,69.23 141.18,69.36 143.89,69.36 145.03,68.21 145.03,67.94 145.16,67.82 145.55,67.82 145.68,67.69 145.68,67.44 145.55,67.31 145.16,67.31 145.03,67.18 145.03,66.93 145.16,66.8 145.55,66.8 145.68,66.67 145.68,66.42 145.55,66.29 145.16,66.29 145.03,66.17 145.03,65.91 145.16,65.78 145.55,65.78 145.68,65.66 145.68,65.4 145.55,65.28 145.16,65.28 145.03,65.15 145.03,64.9 145.16,64.77 145.55,64.77 145.68,64.64 145.68,64.39 145.55,64.26 145.16,64.26 145.03,64.13 145.03,63.88 145.16,63.75 145.55,63.75 145.68,63.63 145.68,63.37 145.55,63.24 145.16,63.24 145.03,63.12 145.03,62.39 133.08,50.43 v2(126.67,50.43)
HDMICONN_CEC: length 27.5
  TOP w0.127: J36.13 85.5,15.24 84.5,14.23 82.48,14.23 81.53,15.18 81.53,26.9 83.26,28.63 87.05,28.63 88.1,27.57 U108.7
HDMICONN_HPLG: length 16.1
  TOP w0.127: U108.10 86.15,27.5 85.86,27.79 83.6,27.79 82.5,26.69 J36.19
HDMICONN_I2CSCL: length 24.8
  TOP w0.127: U108.8 87.45,27.6 86.7,28.35 83.37,28.35 81.81,26.79 81.81,15.3 82.59,14.51 83.97,14.51 84.5,15.05 J36.15
HDMICONN_I2CSDA: length 22.4
  TOP w0.127: J36.16 84,15.09 83.71,14.79 82.71,14.79 82.09,15.41 82.09,26.67 83.49,28.07 86.28,28.07 86.8,27.55 U108.9
HDR_UART2_RXD: length 29.6
  TOP w0.127: J49.4 36.93,98.54 36.32,97.93 33.66,97.93 33.02,98.57 33.02,100.83 34.01,101.82 34.01,107.56 36.65,110.2 43.97,110.2 44.6,109.57 44.6,108.23 44.95,107.89 U124.4
HDR_UART2_TXD: length 20.5
  TOP w0.127: U124.5 44.55,107.89 44.35,108.09 44.35,108.09 44.25,108.2 44.25,109.28 43.66,109.87 36.83,109.87 34.39,107.43 J49.5
INA_ALERT: length 104.3
  TOP w0.127: R789.1 250.82,152.49 251,152.67 v2(251.59,152.67) ; R788.1 v2(269.62,155.46) ; R790.1 v2(235.19,148.62) ; v2(246.51,138.57) 246.76,138.32 R792.1 ; R791.1 v2(235.32,141.6)
  L03_SIG1 w0.127: v2(235.32,141.6) 238.35,138.57 v2(246.51,138.57)
  L08_SIG2 w0.127: J18.4 266.32,124.88 263.73,127.47 255.27,127.47 246.51,136.24 v2(246.51,138.57)
  BOTTOM w0.127: v2(269.62,155.46) R788.1 270.88,154.21 271.27,153.81 271.27,151.78 270.89,151.4 267.59,151.4 266.83,150.64 266.83,149.11 266.45,148.73 261.11,148.73 259.97,147.59 255.52,147.59 254,149.11 254,151.78 253.11,152.67 v2(251.59,152.67) 251.59,152.22 252.98,150.83 252.98,146.28 251.98,145.28 251.98,141.26 249.29,138.57 v2(246.51,138.57) ; v2(235.19,148.62) 235.19,148.18 235.32,148.05 v2(235.32,141.6)
INT: length 29
  TOP w0.127: U30.7 v2(70.73,172.38) ; U20.M3 v1(71.43,195.75)
  L08_SIG2 w0.102: 69.11,193.51 68.91,193.72 68.91,194.81 69.19,195.09 69.77,195.09 70.43,195.75 v1(71.43,195.75)
  L08_SIG2 w0.127: v2(70.73,172.38) 68.69,174.41 68.69,190.9 69.11,191.32 69.11,193.51
INT1: length 30.8
  TOP w0.127: v1(75.06,190.26) 74.93,190.39 U20.W10 ; U24.9 91.17,179.89 v2(90.67,179.39)
  BOTTOM w0.102: 74.22,190.16 74.32,190.26 v1(75.06,190.26)
  BOTTOM w0.127: v2(90.67,179.39) 90.17,179.89 90.17,180.86 89.66,181.37 76.33,181.37 73.03,184.67 73.03,187.21 73.61,187.8 73.61,189.55 74.22,190.16
JTAG_PD: length 20.7
  TOP w0.127: R179.1 97.3,200.53 96.01,201.82 96.01,209.69 99.21,212.89 J7.5
JTAG_RTCK: length 11.4
  TOP w0.127: R133.2 98.18,207.29 98.7,207.81 J7.9
LCD_BLUE0: length 127.8
  TOP w0.127: J22.21 v2(44.64,63.69) ; U81.J2 v1(156.65,66.11)
  L08_SIG2 w0.127: v1(156.65,66.11) 156.25,66.51 156.25,71.48 152.65,75.07 134.87,75.07 134.19,74.39 64.21,74.39 51.52,61.7 48.24,61.7 46.76,63.17 45.16,63.17 v2(44.64,63.69)
LCD_BLUE1: length 128.6
  TOP w0.127: v2(45.4,63.69) 45.14,63.43 J22.22 ; U81.J1 v1(156.65,66.91)
  L08_SIG2 w0.127: v2(45.4,63.69) 46.64,63.69 48.35,61.98 51.46,61.98 52.22,62.74 52.22,63.12 52.2,63.14 64.77,75.71 126.37,75.71 127.13,74.94 132.97,74.94 134.49,76.47 152.02,76.47 156.65,71.83 v1(156.65,66.91)
LCD_BLUE2: length 126.8
  TOP w0.127: U81.K2 v1(155.85,66.11) ; J22.23 v2(45.64,62.68)
  L08_SIG2 w0.127: v2(45.64,62.68) 47.18,61.14 51.85,61.14 64.62,73.9 134.39,73.9 134.67,74.18 151.51,74.18 151.89,73.8 152.07,73.8 152.28,74.02 152.46,74.02 152.64,73.84 152.64,73.66 152.43,73.44 152.43,73.27 152.61,73.09 152.79,73.09 153,73.3 153.18,73.3 153.36,73.12 153.36,72.94 153.15,72.73 153.15,72.55 153.33,72.37 153.51,72.37 153.72,72.58 153.9,72.58 154.08,72.4 154.08,72.22 153.87,72.01 153.87,71.83 154.05,71.65 154.23,71.65 154.44,71.86 154.62,71.86 154.8,71.68 154.8,71.5 154.58,71.29 154.58,71.11 155.46,70.23 155.46,66.5 v1(155.85,66.11)
LCD_BLUE3: length 129.2
  TOP w0.127: J22.24 46.14,62.26 v2(46.56,62.68) ; U81.K1 v1(155.85,66.91)
  L08_SIG2 w0.127: v1(155.85,66.91) 155.85,71.24 152.65,74.44 148.17,74.44 148.04,74.56 148.04,74.7 147.91,74.83 147.66,74.83 147.53,74.7 147.53,74.56 147.4,74.44 147.15,74.44 147.02,74.56 147.02,74.7 146.9,74.83 146.64,74.83 146.52,74.7 146.52,74.56 146.39,74.44 146.13,74.44 146.01,74.56 146.01,74.7 145.88,74.83 145.63,74.83 145.5,74.7 145.5,74.56 145.37,74.44 145.12,74.44 144.99,74.56 144.99,74.7 144.86,74.83 144.61,74.83 144.48,74.7 144.48,74.56 144.36,74.44 144.1,74.44 143.98,74.56 143.98,74.7 143.85,74.83 143.59,74.83 143.47,74.7 143.47,74.56 143.34,74.44 143.09,74.44 142.96,74.56 142.96,74.7 142.83,74.83 142.58,74.83 142.45,74.7 142.45,74.56 142.32,74.44 142.07,74.44 141.94,74.56 141.94,74.7 141.82,74.83 141.56,74.83 141.44,74.7 141.44,74.56 141.31,74.44 141.05,74.44 140.93,74.56 140.93,74.7 140.8,74.83 140.55,74.83 140.42,74.7 140.42,74.56 140.29,74.44 140.04,74.44 139.91,74.56 139.91,74.7 139.78,74.83 139.53,74.83 139.4,74.7 139.4,74.56 139.28,74.44 139.02,74.44 138.9,74.56 138.9,74.7 138.77,74.83 138.51,74.83 138.39,74.7 138.39,74.56 138.26,74.44 138.01,74.44 137.88,74.56 137.88,74.7 137.75,74.83 137.5,74.83 137.37,74.7 137.37,74.56 137.24,74.44 136.99,74.44 136.86,74.56 136.86,74.7 136.74,74.83 136.48,74.83 136.36,74.7 136.36,74.56 136.23,74.44 135.97,74.44 135.85,74.56 135.85,74.7 135.72,74.83 135.47,74.83 135.34,74.7 135.34,74.56 135.21,74.44 134.58,74.44 134.29,74.14 64.35,74.14 51.62,61.42 47.82,61.42 v2(46.56,62.68)
LCD_BLUE4: length 128.6
  TOP w0.127: U81.L2 v1(155.05,66.11) ; v2(47.14,59.63) 46.64,60.13 J22.25
  L08_SIG2 w0.127: v2(47.14,59.63) 47.98,60.47 51.94,60.47 64.74,73.27 135.12,73.27 135.25,73.4 135.25,73.56 135.38,73.69 135.63,73.69 135.76,73.56 135.76,73.4 135.89,73.27 136.14,73.27 136.27,73.4 136.27,73.56 136.39,73.69 136.65,73.69 136.78,73.56 136.78,73.4 136.9,73.27 137.16,73.27 137.28,73.4 137.28,73.56 137.41,73.69 137.66,73.69 137.79,73.56 137.79,73.4 137.92,73.27 138.17,73.27 138.3,73.4 138.3,73.56 138.43,73.69 138.68,73.69 138.81,73.56 138.81,73.4 138.93,73.27 139.19,73.27 139.32,73.4 139.32,73.56 139.44,73.69 139.7,73.69 139.82,73.56 139.82,73.4 139.95,73.27 140.2,73.27 140.33,73.4 140.33,73.56 140.46,73.69 140.71,73.69 140.84,73.56 140.84,73.4 140.97,73.27 141.22,73.27 141.35,73.4 141.35,73.56 141.47,73.69 141.73,73.69 141.86,73.56 141.86,73.4 141.98,73.27 142.24,73.27 142.36,73.4 142.36,73.56 142.49,73.69 142.74,73.69 142.87,73.56 142.87,73.4 143,73.27 143.25,73.27 143.38,73.4 143.38,73.56 143.51,73.69 143.76,73.69 143.89,73.56 143.89,73.4 144.01,73.27 144.27,73.27 144.4,73.4 144.4,73.56 144.52,73.69 144.78,73.69 144.9,73.56 144.9,73.4 145.03,73.27 145.28,73.27 145.41,73.4 145.41,73.56 145.54,73.69 145.79,73.69 145.92,73.56 145.92,73.4 146.05,73.27 146.3,73.27 146.43,73.4 146.43,73.56 146.55,73.69 146.81,73.69 146.94,73.56 146.94,73.4 147.06,73.27 147.32,73.27 147.44,73.4 147.44,73.56 147.57,73.69 147.82,73.69 147.95,73.56 147.95,73.4 148.08,73.27 148.33,73.27 148.46,73.4 148.46,73.56 148.59,73.69 148.84,73.69 148.97,73.56 148.97,73.4 149.09,73.27 149.35,73.27 149.48,73.4 149.48,73.56 149.6,73.69 149.86,73.69 149.98,73.56 149.98,73.4 150.11,73.27 150.27,73.27 154.66,68.87 154.66,66.5 v1(155.05,66.11)
LCD_BLUE5: length 126.9
  TOP w0.127: J22.26 v2(47.14,60.39) ; U81.L1 v1(155.05,66.91)
  L08_SIG2 w0.127: v1(155.05,66.91) 155.05,69.88 154.6,70.34 154.42,70.34 154.09,70.01 153.91,70.01 153.73,70.19 153.73,70.37 154.18,70.82 154.18,71 154,71.18 153.82,71.18 153.37,70.73 153.19,70.73 153.01,70.91 153.01,71.09 153.46,71.54 153.46,71.72 153.29,71.9 153.11,71.9 152.65,71.45 152.47,71.45 152.29,71.62 152.29,71.8 152.75,72.26 152.75,72.44 152.57,72.62 152.39,72.62 151.93,72.16 151.75,72.16 151.57,72.34 151.57,72.52 152.03,72.98 152.03,73.16 151.85,73.34 151.67,73.34 151.21,72.88 151.03,72.88 150.85,73.06 150.85,73.24 151.18,73.57 151.18,73.75 151,73.93 134.75,73.93 134.49,73.66 64.76,73.66 51.95,60.86 47.61,60.86 v2(47.14,60.39)
LCD_BLUE6: length 127.8
  TOP w0.127: U81.M2 v1(154.25,66.11) ; J22.27 47.64,59.94 v2(48.21,59.37)
  L08_SIG2 w0.127: v2(48.21,59.37) 52.73,59.37 58.47,65.11 58.47,65.29 58.2,65.57 58.2,65.75 58.38,65.93 58.56,65.93 58.83,65.65 59.01,65.65 59.19,65.83 59.19,66.01 58.92,66.29 58.92,66.46 59.1,66.64 59.28,66.64 59.55,66.37 59.73,66.37 59.91,66.55 59.91,66.73 59.64,67 59.64,67.18 59.81,67.36 59.99,67.36 60.27,67.09 60.45,67.09 60.63,67.27 60.63,67.45 60.35,67.72 60.35,67.9 60.53,68.08 60.71,68.08 60.99,67.81 61.17,67.81 61.35,67.99 61.35,68.17 61.07,68.44 61.07,68.62 61.25,68.8 61.43,68.8 61.7,68.53 61.88,68.53 62.06,68.71 62.06,68.89 61.79,69.16 61.79,69.34 61.97,69.52 62.15,69.52 62.42,69.24 62.6,69.24 62.78,69.42 62.78,69.6 62.51,69.88 62.51,70.06 62.69,70.24 62.87,70.24 63.14,69.96 63.32,69.96 63.5,70.14 63.5,70.32 63.23,70.6 63.23,70.78 63.41,70.95 63.59,70.95 63.86,70.68 64.04,70.68 64.22,70.86 64.22,71.04 63.95,71.31 63.95,71.49 64.13,71.67 64.31,71.67 64.58,71.4 64.76,71.4 64.94,71.58 64.94,71.76 64.66,72.03 64.66,72.21 64.84,72.39 65.02,72.39 65.3,72.12 65.48,72.12 66.07,72.71 148.92,72.71 153.86,67.77 153.86,66.5 v1(154.25,66.11)
LCD_BLUE7: length 127
  TOP w0.127: J22.28 48.14,60.46 v2(48.72,59.88) ; U81.M1 v1(154.25,66.91)
  L08_SIG2 w0.127: v2(48.72,59.88) 49.38,59.88 49.51,60.01 49.51,60.09 49.63,60.21 49.89,60.21 50.01,60.09 50.01,60.01 50.14,59.88 50.4,59.88 50.52,60.01 50.52,60.09 50.65,60.21 50.9,60.21 51.03,60.09 51.03,60.01 51.16,59.88 51.41,59.88 51.54,60.01 51.54,60.09 51.67,60.21 52.32,60.21 52.58,60.47 52.76,60.47 53.03,60.21 53.21,60.21 53.39,60.39 53.39,60.57 53.12,60.83 53.12,61.01 53.3,61.19 53.48,61.19 53.75,60.93 53.93,60.93 54.11,61.11 54.11,61.29 53.84,61.55 53.84,61.73 54.02,61.91 54.2,61.91 54.47,61.65 54.65,61.65 54.83,61.83 54.83,62 54.56,62.27 54.56,62.45 54.74,62.63 54.92,62.63 55.18,62.36 55.36,62.36 55.54,62.54 55.54,62.72 55.28,62.99 55.28,63.17 55.46,63.35 55.64,63.35 55.9,63.08 56.08,63.08 56.26,63.26 56.26,63.44 56,63.71 56,63.89 56.18,64.07 56.36,64.07 56.62,63.8 56.8,63.8 56.98,63.98 56.98,64.16 56.72,64.43 56.72,64.6 56.9,64.78 57.07,64.78 57.34,64.52 57.52,64.52 57.7,64.7 57.7,64.88 57.43,65.14 57.43,65.32 65.1,72.99 149.53,72.99 149.75,72.77 149.93,72.77 150.02,72.86 150.2,72.86 150.38,72.68 150.38,72.5 150.29,72.41 150.29,72.23 150.47,72.05 150.65,72.05 150.74,72.15 150.92,72.15 151.1,71.97 151.1,71.79 151.01,71.69 151.01,71.51 151.19,71.33 151.37,71.33 151.46,71.43 151.64,71.43 151.82,71.25 151.82,71.07 151.73,70.97 151.73,70.79 151.91,70.61 152.09,70.61 152.18,70.71 152.36,70.71 152.54,70.53 152.54,70.35 152.44,70.25 152.44,70.07 152.62,69.9 152.8,69.9 152.9,69.99 153.08,69.99 153.26,69.81 153.26,69.63 153.16,69.54 153.16,69.36 153.34,69.18 153.52,69.18 153.62,69.27 153.8,69.27 153.98,69.09 153.98,68.91 153.88,68.82 153.88,68.64 154.25,68.26 v1(154.25,66.91)
LCD_DCLK: length 122.4
  TOP w0.127: R510.2 133.15,75.21 v2(132.7,75.66) ; J22.30 v2(49.14,62.54)
  L08_SIG2 w0.127: v2(132.7,75.66) 132.7,76.1 131.88,76.93 120.42,76.93 120.33,77.02 118.33,77.02 117.22,78.12 112.56,78.12 112.43,78.25 112.43,79.01 112.31,79.14 112.05,79.14 111.93,79.01 111.93,78.25 111.8,78.12 111.54,78.12 111.42,78.25 111.42,79.01 111.29,79.14 111.04,79.14 110.91,79.01 110.91,78.25 110.78,78.12 110.53,78.12 110.4,78.25 110.4,79.01 110.27,79.14 110.02,79.14 109.89,79.01 109.89,78.25 109.77,78.12 109.51,78.12 109.39,78.25 109.39,79.01 109.26,79.14 109,79.14 108.88,79.01 108.88,78.25 108.75,78.12 108.5,78.12 108.37,78.25 108.37,79.01 108.24,79.14 107.99,79.14 107.86,79.01 107.86,78.25 107.73,78.12 107.48,78.12 107.35,78.25 107.35,79.01 107.23,79.14 106.97,79.14 106.85,79.01 106.85,78.25 106.72,78.12 106.46,78.12 106.34,78.25 106.34,79.01 106.21,79.14 105.96,79.14 105.83,79.01 105.83,78.25 105.7,78.12 105.45,78.12 105.32,78.25 105.32,79.01 105.19,79.14 104.94,79.14 104.81,79.01 104.81,78.25 104.69,78.12 104.43,78.12 104.31,78.25 104.31,79.01 104.18,79.14 103.92,79.14 103.8,79.01 103.8,78.25 103.67,78.12 103.42,78.12 103.29,78.25 103.29,79.01 103.16,79.14 102.91,79.14 102.78,79.01 102.78,78.25 102.65,78.12 102.11,78.12 99.95,80.28 59.82,80.28 48.89,69.36 48.89,66.56 50.04,65.42 50.04,63.72 49.7,63.38 49.38,63.38 49.14,63.14 v2(49.14,62.54)
LCD_EN: length 124
  TOP w0.127: v2(128.32,75.4) 128.32,74.96 128.57,74.7 R507.2 ; v2(51.14,62.57) J22.34
  L08_SIG2 w0.127: v2(51.14,62.57) 51.18,62.61 51.18,63.13 51.45,63.41 51.45,66.33 61.28,76.15 71.84,76.15 71.97,76.28 71.97,76.85 72.1,76.98 72.35,76.98 72.48,76.85 72.48,76.28 72.6,76.15 72.86,76.15 72.99,76.28 72.99,76.85 73.11,76.98 73.37,76.98 73.49,76.85 73.49,76.28 73.62,76.15 73.87,76.15 74,76.28 74,76.85 74.13,76.98 74.38,76.98 74.51,76.85 74.51,76.28 74.64,76.15 74.89,76.15 75.02,76.28 75.02,76.85 75.14,76.98 75.4,76.98 75.53,76.85 75.53,76.28 75.65,76.15 75.91,76.15 76.03,76.28 76.03,76.85 76.16,76.98 76.41,76.98 76.54,76.85 76.54,76.28 76.67,76.15 76.92,76.15 77.05,76.28 77.05,76.85 77.18,76.98 77.43,76.98 77.56,76.85 77.56,76.28 77.68,76.15 77.94,76.15 78.07,76.28 78.07,76.85 78.19,76.98 78.45,76.98 78.57,76.85 78.57,76.28 78.7,76.15 78.95,76.15 79.08,76.28 79.08,76.85 79.21,76.98 79.46,76.98 79.59,76.85 79.59,76.28 79.72,76.15 79.97,76.15 80.1,76.28 80.1,76.85 80.22,76.98 80.48,76.98 80.61,76.85 80.61,76.28 80.73,76.15 80.99,76.15 81.11,76.28 81.11,76.85 81.24,76.98 81.49,76.98 81.62,76.85 81.62,76.28 81.75,76.15 82,76.15 82.13,76.28 82.13,76.85 82.26,76.98 82.51,76.98 82.64,76.85 82.64,76.28 82.76,76.15 83.02,76.15 83.15,76.28 83.15,76.85 83.27,76.98 83.53,76.98 83.65,76.85 83.65,76.28 83.78,76.15 84.03,76.15 84.16,76.28 84.16,76.85 84.29,76.98 84.54,76.98 84.67,76.85 84.67,76.28 84.8,76.15 85.05,76.15 85.18,76.28 85.18,76.85 85.3,76.98 85.56,76.98 85.69,76.85 85.69,76.28 85.81,76.15 86.07,76.15 86.19,76.28 86.19,76.85 86.32,76.98 86.57,76.98 86.7,76.85 86.7,76.28 86.83,76.15 87.08,76.15 87.21,76.28 87.21,76.85 87.34,76.98 87.59,76.98 87.72,76.85 87.72,76.28 87.84,76.15 88.1,76.15 88.23,76.28 88.23,76.85 88.35,76.98 88.61,76.98 88.73,76.85 88.73,76.28 88.86,76.15 89.11,76.15 89.24,76.28 89.24,76.85 89.37,76.98 89.62,76.98 89.75,76.85 89.75,76.28 89.88,76.15 90.13,76.15 90.26,76.28 90.26,76.85 90.38,76.98 90.64,76.98 90.77,76.85 90.77,76.28 90.89,76.15 91.15,76.15 91.27,76.28 91.27,76.85 91.4,76.98 91.65,76.98 91.78,76.85 91.78,76.28 91.91,76.15 92.16,76.15 92.29,76.28 92.29,76.85 92.42,76.98 92.67,76.98 92.8,76.85 92.8,76.28 92.92,76.15 93.18,76.15 93.31,76.28 93.31,76.85 93.43,76.98 93.69,76.98 93.81,76.85 93.81,76.28 93.94,76.15 94.19,76.15 94.32,76.28 94.32,76.85 94.45,76.98 94.7,76.98 94.83,76.85 94.83,76.28 94.96,76.15 95.21,76.15 95.34,76.28 95.34,76.85 95.46,76.98 95.72,76.98 95.85,76.85 95.85,76.28 95.97,76.15 119.97,76.15 120.06,76.06 127.66,76.06 v2(128.32,75.4)
LCD_GREEN0: length 126.8
  TOP w0.127: J22.13 v2(40.64,60.22) ; U81.N2 v1(153.45,66.11)
  L08_SIG2 w0.127: v1(153.45,66.11) 153.3,66.11 153.06,66.35 153.06,67.09 151.81,68.34 151.59,68.34 151.41,68.52 151.41,68.74 151.2,68.96 150.91,68.96 150.69,69.17 150.69,69.46 150.48,69.68 150.19,69.68 149.97,69.89 149.97,70.18 149.46,70.69 149.21,70.69 148.97,70.93 148.97,71.18 148.74,71.41 148.49,71.41 148.25,71.65 148.25,71.9 148,72.15 66.3,72.15 52.65,58.5 46.98,58.5 45.53,59.95 45.53,60.9 44.46,61.97 42.14,61.97 40.64,60.47 v2(40.64,60.22)
LCD_GREEN1: length 128.1
  TOP w0.127: J22.14 41.14,59.96 v2(40.64,59.46) ; U81.N1 v1(153.45,66.91)
  L08_SIG2 w0.127: v2(40.64,59.46) 40.14,59.96 40.14,60.48 41.91,62.24 44.58,62.24 45.81,61.01 45.81,60.07 47.1,58.78 52.53,58.78 66.18,72.43 148.12,72.43 148.28,72.27 153.45,67.09 v1(153.45,66.91)
LCD_GREEN2: length 127.5
  TOP w0.127: J22.15 v2(41.64,60.22) ; U81.P2 v1(152.65,66.11)
  L08_SIG2 w0.127: v2(41.64,60.22) 41.64,60.45 42.54,61.36 44.28,61.36 44.97,60.66 44.97,60.01 44.97,59.72 46.75,57.94 47.49,57.94 47.62,57.81 47.62,57.53 47.74,57.41 48,57.41 48.12,57.53 48.12,57.81 48.25,57.94 48.5,57.94 48.63,57.81 48.63,57.53 48.76,57.41 49.01,57.41 49.14,57.53 49.14,57.81 49.27,57.94 49.52,57.94 49.65,57.81 49.65,57.53 49.77,57.41 50.03,57.41 50.16,57.53 50.16,57.81 50.28,57.94 50.54,57.94 50.66,57.81 50.66,57.53 50.79,57.41 51.04,57.41 51.17,57.53 51.17,57.81 51.3,57.94 51.55,57.94 51.68,57.81 51.68,57.53 51.81,57.41 52.06,57.41 52.19,57.53 52.19,57.81 52.31,57.94 52.88,57.94 66.53,71.59 147.12,71.59 150.83,67.88 151.43,67.88 152.25,67.07 152.25,66.51 v1(152.65,66.11)
LCD_GREEN3: length 126.9
  TOP w0.127: J22.16 42.14,59.96 v2(41.64,59.46) ; U81.P1 v1(152.65,66.91)
  L08_SIG2 w0.127: v1(152.65,66.91) 152.49,67.07 152.49,67.19 152.36,67.31 152.36,67.31 151.56,68.11 151.23,68.11 149.96,69.38 149.67,69.38 149.49,69.56 149.49,69.74 149.56,69.82 149.56,70 149.38,70.18 149.2,70.18 149.13,70.1 148.95,70.1 148.77,70.28 148.77,70.46 148.84,70.54 148.84,70.72 148.67,70.89 148.49,70.89 148.41,70.82 148.23,70.82 148.05,71 148.05,71.18 148.13,71.25 148.13,71.43 147.69,71.87 66.42,71.87 52.76,58.22 46.87,58.22 45.25,59.83 45.25,60.13 45.25,60.78 44.35,61.69 42.37,61.69 41.18,60.5 41.18,59.92 v2(41.64,59.46)
LCD_GREEN4: length 128.7
  TOP w0.127: U81.R2 v1(151.85,66.11) ; J22.17 v2(42.64,60.22)
  L08_SIG2 w0.127: v1(151.85,66.11) 151.45,66.51 151.45,67.07 151.22,67.3 150.65,67.3 146.91,71.03 67.46,71.03 64.43,68 64.43,67.82 64.52,67.72 64.52,67.54 64.34,67.36 64.16,67.36 64.07,67.46 63.89,67.46 63.71,67.28 63.71,67.1 63.8,67.01 63.8,66.83 63.62,66.65 63.44,66.65 63.35,66.74 63.17,66.74 62.99,66.56 62.99,66.38 63.08,66.29 63.08,66.11 62.9,65.93 62.72,65.93 62.63,66.02 62.45,66.02 62.27,65.84 62.27,65.66 62.37,65.57 62.37,65.39 62.19,65.21 62.01,65.21 61.91,65.3 61.73,65.3 61.55,65.12 61.55,64.94 61.65,64.85 61.65,64.67 61.47,64.49 61.29,64.49 61.19,64.59 61.01,64.59 60.83,64.41 60.83,64.23 60.93,64.13 60.93,63.95 60.75,63.77 60.57,63.77 60.48,63.87 60.3,63.87 60.12,63.69 60.12,63.51 60.21,63.41 60.21,63.23 60.03,63.05 59.85,63.05 59.76,63.15 59.58,63.15 59.4,62.97 59.4,62.79 59.49,62.69 59.49,62.52 59.31,62.34 59.13,62.34 59.04,62.43 58.86,62.43 58.68,62.25 58.68,62.07 58.77,61.98 58.77,61.8 58.59,61.62 58.41,61.62 58.32,61.71 58.14,61.71 57.96,61.53 57.96,61.35 58.05,61.26 58.05,61.08 57.88,60.9 57.7,60.9 57.6,60.99 57.42,60.99 57.24,60.81 57.24,60.63 57.34,60.54 57.34,60.36 57.16,60.18 56.98,60.18 56.88,60.27 56.7,60.27 56.52,60.09 56.52,59.92 56.62,59.82 56.62,59.64 56.44,59.46 56.26,59.46 56.16,59.56 55.99,59.56 55.81,59.38 55.81,59.2 55.9,59.1 55.9,58.92 55.72,58.74 55.54,58.74 55.45,58.84 55.27,58.84 55.09,58.66 55.09,58.48 55.18,58.38 55.18,58.2 55,58.02 54.82,58.02 54.73,58.12 54.55,58.12 54.37,57.94 54.37,57.76 54.46,57.67 54.46,57.49 54.28,57.31 54.1,57.31 54.01,57.4 53.83,57.4 53.21,56.78 47.12,56.78 44.41,59.49 44.41,59.78 44.41,60.25 43.98,60.68 43.1,60.68 v2(42.64,60.22)
LCD_GREEN5: length 127.7
  TOP w0.127: v2(42.64,59.46) 43.14,59.96 J22.18 ; U81.R1 v1(151.85,66.91)
  L08_SIG2 w0.127: v2(42.64,59.46) 42.64,59.52 42.18,59.98 42.18,60.6 42.66,61.08 44.02,61.08 44.69,60.4 44.69,59.9 44.69,59.6 47.13,57.16 52.83,57.16 53.3,57.64 53.48,57.64 53.52,57.61 53.69,57.61 53.87,57.79 53.87,57.97 53.84,58 53.84,58.18 54.02,58.36 54.2,58.36 54.23,58.33 54.41,58.33 54.59,58.5 54.59,58.68 54.56,58.72 54.56,58.89 54.74,59.07 54.92,59.07 54.95,59.04 55.13,59.04 55.31,59.22 55.31,59.4 55.28,59.43 55.28,59.61 55.46,59.79 55.64,59.79 55.67,59.76 55.85,59.76 56.03,59.94 56.03,60.12 56,60.15 56,60.33 56.18,60.51 56.36,60.51 56.39,60.48 56.57,60.48 56.75,60.66 56.75,60.84 56.72,60.87 56.72,61.05 56.9,61.23 57.08,61.23 57.11,61.2 57.29,61.2 57.47,61.38 57.47,61.56 57.44,61.59 57.44,61.77 57.62,61.95 57.79,61.95 57.83,61.92 58.01,61.92 58.18,62.1 58.18,62.28 58.15,62.31 58.15,62.49 58.33,62.67 58.51,62.67 58.54,62.64 58.72,62.64 58.9,62.82 58.9,63 58.87,63.03 58.87,63.21 59.05,63.39 59.23,63.39 59.26,63.35 59.44,63.35 59.62,63.53 59.62,63.71 59.59,63.74 59.59,63.92 59.77,64.1 59.95,64.1 59.98,64.07 60.16,64.07 60.34,64.25 60.34,64.43 60.31,64.46 60.31,64.64 60.49,64.82 60.67,64.82 60.7,64.79 60.88,64.79 61.06,64.97 61.06,65.15 61.03,65.18 61.03,65.36 61.21,65.54 61.39,65.54 61.42,65.51 61.6,65.51 61.78,65.69 61.78,65.87 61.75,65.9 61.75,66.08 61.93,66.26 62.11,66.26 62.14,66.23 62.32,66.23 62.5,66.41 62.5,66.59 62.46,66.62 62.46,66.8 66.98,71.31 146.98,71.31 150.63,67.66 151.19,67.66 151.68,67.16 151.68,67.08 v1(151.85,66.91)
LCD_GREEN6: length 127.7
  TOP w0.127: J22.19 v2(43.64,60.22) ; U81.T1 v1(151.05,66.91)
  L08_SIG2 w0.127: v2(43.64,60.22) 44.13,59.73 44.13,59.67 44.13,59.36 47.22,56.28 53.59,56.28 54.19,56.88 54.37,56.88 54.47,56.78 54.65,56.78 54.83,56.96 54.83,57.14 54.73,57.24 54.73,57.41 54.91,57.59 55.09,57.59 55.19,57.5 55.37,57.5 55.55,57.68 55.55,57.86 55.45,57.95 55.45,58.13 55.63,58.31 55.81,58.31 55.9,58.22 56.08,58.22 56.26,58.4 56.26,58.58 56.17,58.67 56.17,58.85 56.35,59.03 56.53,59.03 56.62,58.94 56.8,58.94 56.98,59.12 56.98,59.3 56.89,59.39 56.89,59.57 57.07,59.75 57.25,59.75 57.34,59.66 57.52,59.66 57.7,59.84 57.7,60.01 57.61,60.11 57.61,60.29 57.79,60.47 57.97,60.47 58.06,60.37 58.24,60.37 58.42,60.55 58.42,60.73 58.33,60.83 58.33,61.01 58.5,61.19 58.68,61.19 58.78,61.09 58.96,61.09 59.14,61.27 59.14,61.45 59.04,61.55 59.04,61.73 59.22,61.91 59.4,61.91 59.5,61.81 59.68,61.81 59.86,61.99 59.86,62.17 59.76,62.26 59.76,62.44 59.94,62.62 60.12,62.62 60.22,62.53 60.4,62.53 60.57,62.71 60.57,62.89 60.48,62.98 60.48,63.16 60.66,63.34 60.84,63.34 60.93,63.25 61.11,63.25 61.29,63.43 61.29,63.61 61.2,63.7 61.2,63.88 61.38,64.06 61.56,64.06 61.65,63.97 61.83,63.97 62.01,64.15 62.01,64.33 61.92,64.42 61.92,64.6 62.1,64.78 62.28,64.78 62.37,64.68 62.55,64.68 62.73,64.86 62.73,65.04 62.64,65.14 62.64,65.32 62.82,65.5 62.99,65.5 63.09,65.4 63.27,65.4 63.45,65.58 63.45,65.76 63.35,65.86 63.35,66.04 63.53,66.22 63.71,66.22 63.81,66.12 63.99,66.12 64.17,66.3 64.17,66.48 64.07,66.57 64.07,66.75 64.25,66.93 64.43,66.93 64.53,66.84 64.71,66.84 64.89,67.02 64.89,67.2 64.79,67.29 64.79,67.47 64.97,67.65 65.15,67.65 65.24,67.56 65.42,67.56 65.6,67.74 65.6,67.92 65.51,68.01 65.51,68.19 65.69,68.37 65.87,68.37 65.96,68.28 66.14,68.28 66.32,68.46 66.32,68.64 66.23,68.73 66.23,68.91 66.41,69.09 66.59,69.09 66.68,69 66.86,69 67.04,69.17 67.04,69.35 66.95,69.45 66.95,69.63 67.13,69.81 67.31,69.81 67.4,69.71 67.58,69.71 67.76,69.89 67.76,70.07 67.66,70.17 67.66,70.35 68.07,70.75 146.69,70.75 150.53,66.91 v1(151.05,66.91)
LCD_GREEN7: length 128.9
  TOP w0.127: v2(43.64,59.46) 44.14,59.96 J22.20 ; U81.T2 v1(151.05,66.11)
  L08_SIG2 w0.127: v2(43.64,59.46) 47.59,55.51 53.72,55.51 54.24,56.03 54.42,56.03 54.75,55.7 54.93,55.7 55.11,55.88 55.11,56.06 54.78,56.39 54.78,56.57 54.96,56.75 55.14,56.75 55.46,56.42 55.64,56.42 55.82,56.6 55.82,56.78 55.5,57.11 55.5,57.29 55.67,57.47 55.85,57.47 56.18,57.14 56.36,57.14 56.54,57.32 56.54,57.5 56.21,57.83 56.21,58.01 56.39,58.19 56.57,58.19 56.9,57.86 57.08,57.86 57.26,58.04 57.26,58.22 56.93,58.55 56.93,58.73 57.11,58.9 57.29,58.9 57.62,58.58 57.8,58.58 57.98,58.76 57.98,58.94 57.65,59.26 57.65,59.44 57.83,59.62 58.01,59.62 58.34,59.29 58.52,59.29 58.7,59.47 58.7,59.65 58.37,59.98 58.37,60.16 58.55,60.34 58.73,60.34 59.06,60.01 59.24,60.01 59.42,60.19 59.42,60.37 59.09,60.7 59.09,60.88 59.27,61.06 59.45,61.06 59.78,60.73 59.95,60.73 60.13,60.91 60.13,61.09 59.81,61.42 59.81,61.6 68.68,70.47 133.88,70.47 134.24,70.12 146.81,70.12 150.83,66.11 v1(151.05,66.11)
LCD_HD: length 124.2
  TOP w0.127: R509.2 131.62,74.84 v2(130.89,75.58) ; J22.32 v2(50.14,62.54)
  L08_SIG2 w0.127: v2(50.14,62.54) 50.14,62.98 50.14,62.99 50.14,63.26 50.59,63.71 50.59,65.76 49.91,66.44 49.91,67.92 50.59,68.6 50.59,70.12 60.11,79.64 99.06,79.64 102.07,76.63 102.86,76.63 102.99,76.76 102.99,77.48 103.12,77.61 103.37,77.61 103.5,77.48 103.5,76.76 103.62,76.63 103.88,76.63 104.01,76.76 104.01,77.48 104.13,77.61 104.39,77.61 104.51,77.48 104.51,76.76 104.64,76.63 104.89,76.63 105.02,76.76 105.02,77.48 105.15,77.61 105.4,77.61 105.53,77.48 105.53,76.76 105.66,76.63 105.91,76.63 106.04,76.76 106.04,77.48 106.16,77.61 106.42,77.61 106.55,77.48 106.55,76.76 106.67,76.63 106.93,76.63 107.05,76.76 107.05,77.48 107.18,77.61 107.43,77.61 107.56,77.48 107.56,76.76 107.69,76.63 107.94,76.63 108.07,76.76 108.07,77.48 108.2,77.61 108.45,77.61 108.58,77.48 108.58,76.76 108.7,76.63 108.96,76.63 109.09,76.76 109.09,77.48 109.21,77.61 109.47,77.61 109.59,77.48 109.59,76.76 109.72,76.63 109.97,76.63 110.1,76.76 110.1,77.48 110.23,77.61 110.48,77.61 110.61,77.48 110.61,76.76 110.74,76.63 110.99,76.63 111.12,76.76 111.12,77.48 111.24,77.61 111.5,77.61 111.63,77.48 111.63,76.76 111.75,76.63 112.01,76.63 112.13,76.76 112.13,77.48 112.26,77.61 112.51,77.61 112.64,77.48 112.64,76.76 112.77,76.63 113.02,76.63 113.15,76.76 113.15,77.48 113.28,77.61 113.53,77.61 113.66,77.48 113.66,76.76 113.78,76.63 114.04,76.63 114.17,76.76 114.17,77.48 114.29,77.61 114.55,77.61 114.67,77.48 114.67,76.76 114.8,76.63 115.05,76.63 115.18,76.76 115.18,77.48 115.31,77.61 115.56,77.61 115.69,77.48 115.69,76.76 115.82,76.63 116.07,76.63 116.2,76.76 116.2,77.48 116.32,77.61 116.58,77.61 116.71,77.48 116.71,76.76 116.83,76.63 120.17,76.63 120.26,76.55 129.92,76.55 v2(130.89,75.58)
LCD_RED0: length 127.1
  TOP w0.127: J22.5 v2(36.64,62.69) ; U82.G2 v1(133.65,65.72)
  L08_SIG2 w0.127: v1(133.65,65.72) 134.05,66.11 134.05,66.68 133.98,66.74 133.98,69.56 133.35,70.2 68.91,70.2 60.58,61.86 60.58,60.85 54.61,54.88 47.37,54.88 43.92,58.33 43.24,58.33 43.11,58.46 43.11,58.88 42.98,59 42.73,59 42.6,58.88 42.6,58.46 42.47,58.33 42.22,58.33 41.57,57.68 41.39,57.68 41.21,57.86 41.21,58.04 41.54,58.37 41.54,58.55 41.36,58.73 41.18,58.73 40.85,58.4 40.67,58.4 39.71,59.36 39.71,60.47 41.81,62.57 41.81,62.58 41.81,62.58 41.81,64.77 41.65,64.93 41.27,65.31 40.3,66.28 37.92,66.28 36.28,64.65 36.28,63.04 v2(36.64,62.69)
LCD_RED1: length 128.9
  TOP w0.127: v2(36.78,63.82) 37.14,63.46 J22.6 ; U82.G1 v1(133.65,66.52)
  L08_SIG2 w0.127: v2(36.78,63.82) 36.78,64.45 38.3,65.98 40.21,65.98 41.15,65.03 41.53,64.65 41.53,62.7 41.53,62.7 41.53,62.68 39.43,60.59 39.43,58.86 41.14,57.15 42.03,57.15 42.16,57.28 42.16,57.67 42.28,57.8 42.54,57.8 42.66,57.67 42.66,57.28 42.79,57.15 42.81,57.15 42.98,56.97 43.16,56.97 43.81,57.62 43.99,57.62 44.17,57.44 44.17,57.26 43.52,56.61 43.52,56.43 43.7,56.25 43.88,56.25 44.53,56.9 44.71,56.9 44.89,56.72 44.89,56.54 44.24,55.9 44.24,55.72 44.42,55.54 44.6,55.54 45.4,56.33 45.58,56.33 45.76,56.15 45.76,55.97 45.21,55.43 45.21,55.13 45.97,54.37 54.61,54.37 60.96,60.72 60.96,61.74 69.14,69.92 131.95,69.92 133.65,68.21 v1(133.65,66.52)
LCD_RED2: length 128.1
  TOP w0.127: J22.7 v2(37.64,63.45) ; U82.H1 v1(132.85,66.52)
  L08_SIG2 w0.127: v2(37.64,63.45) 38.14,63.95 38.14,64.47 39.07,65.39 40,65.39 40.97,64.42 40.97,62.93 40.97,62.93 40.97,62.91 38.87,60.82 38.87,58.5 43.7,53.67 54.59,53.67 61.95,61.03 61.95,61.21 61.62,61.54 61.62,61.72 61.8,61.9 61.98,61.9 62.31,61.57 62.49,61.57 62.67,61.75 62.67,61.93 62.34,62.26 62.34,62.44 62.52,62.61 62.7,62.61 63.03,62.29 63.21,62.29 63.39,62.47 63.39,62.65 63.06,62.97 63.06,63.15 63.24,63.33 63.42,63.33 63.75,63 63.93,63 64.11,63.18 64.11,63.36 63.78,63.69 63.78,63.87 63.96,64.05 64.14,64.05 64.47,63.72 64.64,63.72 64.82,63.9 64.82,64.08 64.5,64.41 64.5,64.59 64.68,64.77 64.86,64.77 65.18,64.44 65.36,64.44 65.54,64.62 65.54,64.8 65.21,65.13 65.21,65.31 65.39,65.49 65.57,65.49 65.9,65.16 66.08,65.16 66.26,65.34 66.26,65.52 65.93,65.85 65.93,66.03 66.11,66.21 66.29,66.21 66.62,65.88 66.8,65.88 66.98,66.06 66.98,66.24 66.65,66.57 66.65,66.75 66.83,66.93 67.01,66.93 67.34,66.6 67.52,66.6 67.7,66.78 67.7,66.96 67.37,67.28 67.37,67.46 67.55,67.64 67.73,67.64 68.06,67.32 68.24,67.32 70.28,69.36 130.05,69.36 131.55,67.86 131.55,67.83 v1(132.85,66.52)
LCD_RED3: length 128.1
  TOP w0.127: J22.8 38.14,63.71 v2(37.64,64.21) ; U82.H2 v1(132.85,65.72)
  L08_SIG2 w0.127: v2(37.64,64.21) 37.64,64.65 38.66,65.67 40.12,65.67 41.04,64.75 41.25,64.54 41.25,62.81 41.25,62.81 41.25,62.8 39.15,60.7 39.15,58.74 41.56,56.34 41.74,56.34 42.34,56.94 42.52,56.94 42.7,56.76 42.7,56.58 42.09,55.98 42.09,55.8 42.27,55.62 42.45,55.62 43.06,56.22 43.23,56.22 43.41,56.04 43.41,55.86 42.81,55.26 42.81,55.08 42.99,54.9 43.17,54.9 43.77,55.5 43.95,55.5 44.13,55.32 44.13,55.14 43.53,54.54 43.53,54.36 43.94,53.95 44.3,53.95 44.43,54.08 44.43,54.75 44.55,54.88 44.81,54.88 44.93,54.75 44.93,54.08 45.06,53.95 54.53,53.95 61.2,60.62 61.2,61.64 69.2,69.64 130.51,69.64 133.25,66.89 133.25,66.06 132.91,65.72 v1(132.85,65.72)
LCD_RED4: length 129.1
  TOP w0.127: J22.9 v2(38.64,63.45) ; U82.J2 v1(131.25,65.72)
  L08_SIG2 w0.127: v2(38.64,63.45) 39.14,63.95 39.14,64.42 39.43,64.71 39.84,64.71 40.41,64.14 40.41,63.16 40.41,63.16 40.41,63.15 38.32,61.05 38.32,59.87 38.32,58.32 39.4,57.24 43.52,53.11 55.36,53.11 55.67,53.43 55.85,53.43 56.02,53.26 56.2,53.26 56.38,53.43 56.38,53.61 56.21,53.79 56.21,53.97 56.39,54.15 56.57,54.15 56.74,53.97 56.92,53.97 57.1,54.15 57.1,54.33 56.93,54.5 56.93,54.68 57.11,54.86 57.29,54.86 57.46,54.69 57.64,54.69 57.82,54.87 57.82,55.05 57.65,55.22 57.65,55.4 57.83,55.58 58,55.58 58.18,55.41 58.36,55.41 58.54,55.59 58.54,55.77 58.36,55.94 58.36,56.12 58.54,56.3 58.72,56.3 58.9,56.13 59.07,56.13 59.25,56.31 59.25,56.49 59.08,56.66 59.08,56.84 59.26,57.02 59.44,57.02 59.61,56.85 59.79,56.85 59.97,57.03 59.97,57.21 59.8,57.38 59.8,57.56 59.98,57.74 60.16,57.74 60.33,57.57 60.51,57.57 60.69,57.75 60.69,57.92 60.52,58.1 60.52,58.28 60.7,58.46 60.88,58.46 61.05,58.28 61.23,58.28 61.41,58.46 61.41,58.64 61.24,58.82 61.24,58.99 61.42,59.17 61.6,59.17 61.77,59 61.95,59 62.13,59.18 62.13,59.36 61.96,59.53 61.96,59.71 62.14,59.89 62.32,59.89 62.49,59.72 62.67,59.72 62.85,59.9 62.85,60.08 62.67,60.25 62.67,60.43 62.85,60.61 63.03,60.61 63.21,60.44 63.39,60.44 63.56,60.62 63.56,60.8 63.39,60.97 63.39,61.15 63.57,61.33 63.75,61.33 63.92,61.16 64.1,61.16 64.28,61.34 64.28,61.52 64.11,61.69 64.11,61.87 64.29,62.05 64.47,62.05 64.64,61.88 64.82,61.88 65,62.06 65,62.24 64.83,62.41 64.83,62.59 65.01,62.77 65.19,62.77 65.36,62.59 65.54,62.59 65.72,62.77 65.72,62.95 65.55,63.13 65.55,63.31 65.73,63.48 65.91,63.48 66.08,63.31 66.26,63.31 66.44,63.49 66.44,63.67 66.27,63.84 66.27,64.02 66.45,64.2 66.63,64.2 66.8,64.03 66.98,64.03 67.16,64.21 67.16,64.39 66.99,64.56 66.99,64.74 67.16,64.92 67.34,64.92 67.52,64.75 67.7,64.75 67.88,64.93 67.88,65.11 67.7,65.28 67.7,65.46 67.88,65.64 68.06,65.64 68.23,65.47 68.41,65.47 68.59,65.65 68.59,65.83 68.42,66 68.42,66.18 68.6,66.36 68.78,66.36 68.95,66.19 69.13,66.19 69.31,66.37 69.31,66.55 69.14,66.72 69.14,66.9 71.04,68.8 129.8,68.8 130.85,67.75 130.85,66.12 v1(131.25,65.72)
LCD_RED5: length 127.3
  TOP w0.127: U82.J1 v1(131.25,66.52) ; J22.10 39.14,63.71 v2(38.64,64.21)
  L08_SIG2 w0.127: v2(38.64,64.21) 38.64,64.38 39.37,65.12 39.88,65.12 40.69,64.31 40.69,63.05 40.69,63.04 40.69,63.03 38.59,60.93 38.59,59.76 38.59,58.44 39.51,57.52 43.64,53.39 55.24,53.39 55.42,53.57 55.42,53.75 55.31,53.87 55.31,54.04 55.49,54.22 55.67,54.22 55.78,54.11 55.96,54.11 56.14,54.29 56.14,54.47 56.03,54.58 56.03,54.76 56.21,54.94 56.39,54.94 56.5,54.83 56.68,54.83 56.86,55.01 56.86,55.19 56.74,55.3 56.74,55.48 56.92,55.66 57.1,55.66 57.22,55.55 57.4,55.55 57.58,55.73 57.58,55.91 57.46,56.02 57.46,56.2 57.64,56.38 57.82,56.38 57.93,56.27 58.11,56.27 58.29,56.45 58.29,56.63 58.18,56.74 58.18,56.92 58.36,57.1 58.54,57.1 58.65,56.99 58.83,56.99 59.01,57.16 59.01,57.34 58.9,57.46 58.9,57.64 59.08,57.82 59.26,57.82 59.37,57.7 59.55,57.7 59.73,57.88 59.73,58.06 59.62,58.18 59.62,58.36 59.8,58.53 59.98,58.53 60.09,58.42 60.27,58.42 60.45,58.6 60.45,58.78 60.34,58.89 60.34,59.07 60.52,59.25 60.7,59.25 60.81,59.14 60.99,59.14 61.17,59.32 61.17,59.5 61.05,59.61 61.05,59.79 61.23,59.97 61.41,59.97 61.53,59.86 61.71,59.86 61.89,60.04 61.89,60.22 61.77,60.33 61.77,60.51 61.95,60.69 62.13,60.69 62.25,60.58 62.43,60.58 62.6,60.76 62.6,60.94 62.49,61.05 62.49,61.23 62.67,61.41 62.85,61.41 62.96,61.3 63.14,61.3 63.32,61.48 63.32,61.65 63.21,61.77 63.21,61.95 63.39,62.13 63.57,62.13 63.68,62.01 63.86,62.01 64.04,62.19 64.04,62.37 63.93,62.49 63.93,62.67 64.11,62.85 64.29,62.85 64.4,62.73 64.58,62.73 64.76,62.91 64.76,63.09 64.65,63.2 64.65,63.38 64.83,63.56 65.01,63.56 65.12,63.45 65.3,63.45 65.48,63.63 65.48,63.81 65.37,63.92 65.37,64.1 65.55,64.28 65.72,64.28 65.84,64.17 66.02,64.17 66.2,64.35 66.2,64.53 66.08,64.64 66.08,64.82 66.26,65 66.44,65 66.56,64.89 66.74,64.89 66.92,65.07 66.92,65.25 66.8,65.36 66.8,65.54 66.98,65.72 67.16,65.72 67.27,65.61 67.45,65.61 67.63,65.79 67.63,65.97 67.52,66.08 67.52,66.26 67.7,66.44 67.88,66.44 67.99,66.32 68.17,66.32 68.35,66.5 68.35,66.68 68.24,66.8 68.24,66.98 68.42,67.16 68.6,67.16 68.71,67.04 68.89,67.04 69.07,67.22 69.07,67.4 68.96,67.52 68.96,67.69 69.14,67.87 69.32,67.87 69.43,67.76 69.61,67.76 69.79,67.94 69.79,68.12 69.68,68.23 69.68,68.41 69.86,68.59 70.04,68.59 70.15,68.48 70.33,68.48 70.93,69.08 129.91,69.08 131.25,67.74 v1(131.25,66.52)
LCD_RED6: length 127.4
  TOP w0.127: J22.11 v2(39.64,63.45) ; U82.K2 v1(130.45,65.72)
  L08_SIG2 w0.127: v2(39.64,63.45) 37.76,61.57 37.76,60.11 37.76,58.09 39.17,56.68 43.29,52.55 57.24,52.55 57.68,53 57.86,53 58.26,52.61 58.44,52.61 58.62,52.79 58.62,52.97 58.22,53.36 58.22,53.54 58.4,53.72 58.58,53.72 58.97,53.33 59.15,53.33 59.33,53.51 59.33,53.69 58.94,54.08 58.94,54.26 59.12,54.44 59.3,54.44 59.69,54.05 59.87,54.05 60.05,54.23 60.05,54.41 59.66,54.8 59.66,54.98 59.84,55.16 60.02,55.16 60.41,54.76 60.59,54.76 60.77,54.94 60.77,55.12 60.38,55.52 60.38,55.69 60.56,55.87 60.74,55.87 61.13,55.48 61.31,55.48 61.49,55.66 61.49,55.84 61.1,56.23 61.1,56.41 61.28,56.59 61.46,56.59 61.85,56.2 62.03,56.2 62.21,56.38 62.21,56.56 61.82,56.95 61.82,57.13 62,57.31 62.18,57.31 62.57,56.92 62.75,56.92 62.93,57.1 62.93,57.28 62.53,57.67 62.53,57.85 62.71,58.03 62.89,58.03 63.29,57.64 63.46,57.64 63.64,57.82 63.64,58 63.25,58.39 63.25,58.57 63.43,58.75 63.61,58.75 64,58.36 64.18,58.36 64.36,58.54 64.36,58.72 63.97,59.11 63.97,59.29 64.15,59.47 64.33,59.47 64.72,59.07 64.9,59.07 65.08,59.25 65.08,59.43 64.69,59.83 64.69,60.01 64.87,60.19 65.05,60.19 65.44,59.79 65.62,59.79 65.8,59.97 65.8,60.15 65.41,60.54 65.41,60.72 65.59,60.9 65.77,60.9 66.16,60.51 66.34,60.51 66.52,60.69 66.52,60.87 66.13,61.26 66.13,61.44 72.92,68.24 128.53,68.24 130.05,66.71 130.05,66.12 v1(130.45,65.72)
LCD_RED7: length 127.5
  TOP w0.127: J22.12 40.14,63.71 v2(39.64,64.21) ; U82.K1 v1(130.45,66.52)
  L08_SIG2 w0.127: v2(39.64,64.21) 40.13,63.72 40.13,63.26 38.04,61.16 38.04,59.99 38.04,58.21 39.28,56.96 43.41,52.83 56.12,52.83 56.68,53.4 56.86,53.4 57.06,53.19 57.24,53.19 57.42,53.37 57.42,53.55 57.22,53.75 57.22,53.93 57.4,54.11 57.58,54.11 57.78,53.91 57.96,53.91 58.14,54.09 58.14,54.27 57.94,54.47 57.94,54.65 58.12,54.83 58.3,54.83 58.5,54.63 58.68,54.63 58.86,54.81 58.86,54.99 58.66,55.19 58.66,55.37 58.84,55.55 59.02,55.55 59.22,55.35 59.4,55.35 59.58,55.53 59.58,55.71 59.38,55.91 59.38,56.09 59.56,56.27 59.74,56.27 59.94,56.07 60.12,56.07 60.3,56.25 60.3,56.43 60.09,56.63 60.09,56.81 60.27,56.99 60.45,56.99 60.66,56.79 60.84,56.79 61.01,56.97 61.01,57.15 60.81,57.35 60.81,57.53 60.99,57.71 61.17,57.71 61.37,57.5 61.55,57.5 61.73,57.68 61.73,57.86 61.53,58.07 61.53,58.24 61.71,58.42 61.89,58.42 62.09,58.22 62.27,58.22 62.45,58.4 62.45,58.58 62.25,58.78 62.25,58.96 62.43,59.14 62.61,59.14 62.81,58.94 62.99,58.94 63.17,59.12 63.17,59.3 62.97,59.5 62.97,59.68 63.15,59.86 63.33,59.86 63.53,59.66 63.71,59.66 63.89,59.84 63.89,60.02 63.69,60.22 63.69,60.4 63.87,60.58 64.05,60.58 64.25,60.38 64.43,60.38 64.61,60.56 64.61,60.74 64.41,60.94 64.41,61.12 64.58,61.3 64.76,61.3 64.97,61.1 65.15,61.1 65.33,61.28 65.33,61.46 65.12,61.66 65.12,61.84 65.3,62.02 65.48,62.02 65.68,61.81 65.86,61.81 66.04,61.99 66.04,62.17 65.84,62.38 65.84,62.56 66.02,62.73 66.2,62.73 66.4,62.53 66.58,62.53 66.76,62.71 66.76,62.89 66.56,63.09 66.56,63.27 66.74,63.45 66.92,63.45 67.12,63.25 67.3,63.25 67.48,63.43 67.48,63.61 67.28,63.81 67.28,63.99 67.46,64.17 67.64,64.17 67.84,63.97 68.02,63.97 68.2,64.15 68.2,64.33 68,64.53 68,64.71 68.18,64.89 68.36,64.89 68.56,64.69 68.74,64.69 68.92,64.87 68.92,65.05 68.72,65.25 68.72,65.43 68.9,65.61 69.08,65.61 69.28,65.41 69.46,65.41 69.64,65.59 69.64,65.77 69.43,65.97 69.43,66.15 69.61,66.33 69.79,66.33 69.99,66.13 70.17,66.13 70.35,66.31 70.35,66.48 70.15,66.69 70.15,66.87 71.81,68.52 128.64,68.52 130.45,66.71 v1(130.45,66.52)
LCD_VD: length 123
  TOP w0.127: R508.2 130.1,74.88 v2(129.49,75.49) ; v2(50.64,63.06) J22.33
  L08_SIG2 w0.127: v2(50.64,63.06) 51.01,63.43 51.01,69.48 59.52,77.99 63.98,77.99 64.1,78.12 64.1,78.5 64.23,78.63 64.48,78.63 64.61,78.5 64.61,78.12 64.74,77.99 64.99,77.99 65.12,78.12 65.12,78.5 65.25,78.63 65.5,78.63 65.63,78.5 65.63,78.12 65.75,77.99 66.01,77.99 66.13,78.12 66.13,78.5 66.26,78.63 66.52,78.63 66.64,78.5 66.64,78.12 66.77,77.99 67.02,77.99 67.15,78.12 67.15,78.5 67.28,78.63 67.53,78.63 67.66,78.5 67.66,78.12 67.79,77.99 68.04,77.99 68.17,78.12 68.17,78.5 68.29,78.63 68.55,78.63 68.67,78.5 68.67,78.12 68.8,77.99 69.06,77.99 69.18,78.12 69.18,78.5 69.31,78.63 69.56,78.63 69.69,78.5 69.69,78.12 69.82,77.99 70.07,77.99 70.2,78.12 70.2,78.5 70.33,78.63 70.58,78.63 70.71,78.5 70.71,78.12 70.83,77.99 71.09,77.99 71.21,78.12 71.21,78.5 71.34,78.63 71.6,78.63 71.72,78.5 71.72,78.12 71.85,77.99 72.1,77.99 72.23,78.12 72.23,78.5 72.36,78.63 72.61,78.63 72.74,78.5 72.74,78.12 72.87,77.99 73.12,77.99 73.25,78.12 73.25,78.5 73.37,78.63 73.63,78.63 73.75,78.5 73.75,78.12 73.88,77.99 74.14,77.99 74.26,78.12 74.26,78.5 74.39,78.63 74.64,78.63 74.77,78.5 74.77,78.12 74.9,77.99 75.15,77.99 75.28,78.12 75.28,78.5 75.41,78.63 75.66,78.63 75.79,78.5 75.79,78.12 75.91,77.99 76.17,77.99 76.29,78.12 76.29,78.5 76.42,78.63 76.68,78.63 76.8,78.5 76.8,78.12 76.93,77.99 77.18,77.99 77.31,78.12 77.31,78.5 77.44,78.63 77.69,78.63 77.82,78.5 77.82,78.12 77.95,77.99 78.2,77.99 78.33,78.12 78.33,78.5 78.45,78.63 78.71,78.63 78.83,78.5 78.83,78.12 78.96,77.99 79.22,77.99 79.34,78.12 79.34,78.5 79.47,78.63 79.72,78.63 79.85,78.5 79.85,78.12 79.98,77.99 80.23,77.99 80.36,78.12 80.36,78.5 80.49,78.63 80.74,78.63 80.87,78.5 80.87,78.12 80.99,77.99 81.25,77.99 81.37,78.12 81.37,78.5 81.5,78.63 81.76,78.63 81.88,78.5 81.88,78.12 82.01,77.99 82.26,77.99 82.39,78.12 82.39,78.5 82.52,78.63 82.77,78.63 82.9,78.5 82.9,78.12 83.03,77.99 83.28,77.99 83.41,78.12 83.41,78.5 83.53,78.63 83.79,78.63 83.91,78.5 83.91,78.12 84.04,77.99 84.3,77.99 84.42,78.12 84.42,78.5 84.55,78.63 84.8,78.63 84.93,78.5 84.93,78.12 85.06,77.99 85.31,77.99 85.44,78.12 85.44,78.5 85.57,78.63 85.82,78.63 85.95,78.5 85.95,78.12 86.07,77.99 86.33,77.99 86.45,78.12 86.45,78.5 86.58,78.63 86.84,78.63 86.96,78.5 86.96,78.12 87.09,77.99 87.34,77.99 87.47,78.12 87.47,78.5 87.6,78.63 87.85,78.63 87.98,78.5 87.98,78.12 88.11,77.99 88.36,77.99 88.49,78.12 88.49,78.5 88.61,78.63 88.87,78.63 88.99,78.5 88.99,78.12 89.12,77.99 89.38,77.99 89.5,78.12 89.5,78.5 89.63,78.63 89.88,78.63 90.01,78.5 90.01,78.12 90.14,77.99 90.39,77.99 90.52,78.12 90.52,78.5 90.65,78.63 90.9,78.63 91.03,78.5 91.03,78.12 91.15,77.99 98.93,77.99 100.53,76.39 120.07,76.39 120.16,76.3 128.68,76.3 v2(129.49,75.49)
LDO1_1V8: length 636
  TOP w0.203: 245.64,142.1 245.64,141.67 245.32,141.35 U46.10 243.01,141.35 242.85,141.19 242.85,140.53 243.03,140.35 U46.8 ; 246.47,168.18 U32.N6
  TOP w0.229: C758.2 133.34,107.08 131.7,107.08 U123.A2
  TOP w0.254: C813.1 v2(217.84,212.4)
  TOP w0.381: J42.1 244.98,145.24 243.8,146.42 242.59,146.42 v2(242.19,146.83) ; J42.1 244.98,142.76 245.64,142.1 ; J42.1 247.78,144.03 R381.2 248.16,145.3 v2(247.78,145.68) ; U122.6 134.3,102.72 134.33,102.75 C757.1 v2(135,103.65) 136.02,104.66 136.02,107.08 135,108.09 133.73,108.09 133.39,107.75 C758.2 ; C813.1 216.94,212.35 U142.19 ; R536.1 v2(283.31,47.39) ; v2(171.96,195.21) 171.96,194.45 172.29,194.12 R258.1 ; v2(152.1,97.83) 152.43,98.16 152.43,98.19 R896.1 ; C152.2 247.4,167.25 246.47,168.18
  TOP w0.508: C158.1 247.74,161.19 247.27,160.72 247.27,157.62 TP122.1
  L03_SIG1 w0.381: v2(172.52,208.19) 173.35,208.19 175.51,210.35 175.51,212.66 175.89,213.04 v2(175.95,213.04) ; J42.1 247.78,144.03 248.68,144.93 248.68,147.47 248.74,147.53 248.74,149.39 250.09,150.74 250.09,155.95 249.55,156.48 TP122.1 ; v2(171.96,195.21) 171.91,195.16 169.98,195.16 167.97,193.16 167.97,191.56 166.62,190.21 148.31,190.21 146.84,188.74 126.06,188.74 124.32,186.99 122.85,186.99 122.58,187.26 122.56,187.26 122.22,187.59 122.22,187.62 122.07,187.77 121.26,187.77 120.6,187.11 v2(116.33,187.11)
  L03_SIG1 w0.508: 244.98,142.97 J42.1 ; J42.1 244.98,145.1 ; J42.1 243.92,144.03 ; 247.41,156.48 TP122.1 248.41,157.48
  L08_SIG2 w0.254: v2(283.31,47.39) 285.42,47.39 289.74,51.7 290.43,51.7 292.43,53.7 292.43,94.48 295.3,97.35 295.3,117.85 282.45,130.7 277.72,130.7 276.43,131.99 276.43,146.78 272.19,151.02 268.94,151.02 267.18,152.77 254.71,152.77 251,156.48 TP122.1
  L08_SIG2 w0.381: v2(152.1,97.83) 152.04,97.83 151.46,97.25 147.78,97.25 146.79,98.24 141.68,98.24 140.11,99.81 125.65,99.81 124.61,100.85 115.06,100.85 113.03,102.88 112.9,102.88 111.48,104.31 111.48,104.41 110.82,105.07 110.82,125.72 117.3,132.2 117.3,175.86 114.17,178.98 114.17,184.19 114.02,184.34 114.02,184.39 113.75,184.66 113.75,186.38 114.05,186.68 115.9,186.68 v2(116.33,187.11) ; v2(171.96,195.21) 171.96,201.87 172.44,202.35 172.44,208.12 v2(172.52,208.19) ; v2(242.19,146.83) 241.15,147.87 241.15,147.9 238.61,150.43 238.58,150.43 238.51,150.51 229.13,150.51 226.11,153.53 226.11,169.41 230.73,174.03 230.73,184.14 229.97,184.9 229.97,192.85 235.92,198.8 235.92,202.22 225.74,212.4 v2(217.84,212.4) 213.36,207.91 211.53,207.91 209.91,209.54 200.48,209.54 196.98,213.04 v2(175.95,213.04) 174.35,214.64 169.34,214.64 168.17,215.81 168.17,217.92 168.94,218.68 168.94,221.93 167.64,223.23 167.64,227.95 v1(168.33,228.64)
  BOTTOM w0.381: C722.1 C721.1 248.79,144.67 v2(247.78,145.68) 247.27,145.18 C722.1 ; C722.1 245.86,143.16 J42.1 ; FB9.1 v1(168.33,228.64)
  BOTTOM w0.508: v2(152.1,97.83) 152.65,97.27 152.65,94.6 150.52,92.47 145.59,92.47 142.14,95.93 142.14,99.86 140.03,101.97 136.68,101.97 v2(135,103.65)
LDO2_1V8: length 377.7
  TOP w0.203: 245.17,167.93 U32.N4
  TOP w0.381: U142.2 C812.2 v2(206.69,213.13) ; 245.17,167.93 245.75,167.35 C151.2 245.75,165.88 245.69,165.82 245.23,165.82 245,165.59 245,165.13 244.98,165.11 ; v1(168.33,230.16) 167.56,229.4 167.56,228.44 168.29,227.72 FB8.1 ; R543.1 283.34,45.73 v2(283.36,45.71)
  L03_SIG1 w0.381: v2(289.48,141.34) 280.95,141.34 276.25,146.04 270.36,146.04 265.53,150.87 256.26,150.87 254.38,152.75 254.38,156.86 258.19,160.67 TP118.1
  L08_SIG2 w0.254: v2(289.48,141.34) 289.48,132.25 297.16,124.58 297.16,97.3 292.83,92.98 292.83,63.44 293.65,62.63 293.65,56.94 294.67,55.92 294.67,55.16 293.85,54.35 293.85,53.56 291.21,50.91 290.07,50.91 284.86,45.71 v2(283.36,45.71)
  L08_SIG2 w0.381: v2(244.86,162.7) 244.86,164.61 244.22,165.24 244.22,171.62 243.71,172.13 243.71,173.75 241.91,175.55 241.91,180.46 243.56,182.11 253.09,182.11 254,183.02 254,190.64 235.46,209.18 v2(235.46,218.07) 230.25,218.07 226.57,214.39 213.61,214.39 211.45,212.23 207.59,212.23 v2(206.69,213.13)
  BOTTOM w0.381: v2(244.86,162.7) v2(246.25,162.7) 258.32,162.7 TP118.1
  BOTTOM w0.762: v1(168.33,230.16) 173.71,230.16 180.21,223.66 180.21,216.85 181.74,215.33 186.87,215.33 193.42,221.88 196.98,221.88 199.26,219.6 209.04,219.6 211.71,222.26 214.25,222.26 217.8,218.71 234.82,218.71 v2(235.46,218.07)
LDO3_1V8: length 355.6
  TOP w0.178: v2(249.68,175.15) 249.28,174.74 247.98,174.74 247.44,174.74 U32.E7
  TOP w0.381: R857.1 153.31,96.58 v2(153.31,95.42) ; v2(187.58,191.02) 187.47,190.91 R856.1
  L03_SIG1 w0.381: v2(203.71,211.22) 199.9,211.22 198.5,212.61 182.63,212.61 181.74,211.72 181.74,207.53 190.5,198.77 190.5,193.94 v2(187.58,191.02) 186.08,191.02 177.5,199.61 176.38,199.61 175.7,200.28 173.85,200.28 172.85,199.28 172.85,197.55 171.4,196.1 169.8,196.1 167.13,193.44 167.19,193.38 167.04,193.23 167.04,192.59 167.09,192.54 167.09,192.05 166.45,191.4 126.37,191.4 v2(122.81,187.85)
  L08_SIG2 w0.381: v2(203.71,211.22) 211.96,211.22 212.72,210.45 214.25,210.45 217.17,213.37 229.23,213.37 252.86,189.75 v2(252.86,182.89) ; v2(153.31,95.42) 153.31,94.85 152.59,94.12 147.19,94.12 145.54,95.77 139.45,95.77 138.68,95.01 135.56,95.01 134.51,93.97 133.24,93.97 132.45,94.76 114.64,94.76 113.86,95.54 112.88,95.54 109.87,98.55 109.87,132.21 107.19,134.89 107.19,144.29 113.03,150.13 TP103.1 113.03,186.7 113.67,187.34 115.09,187.34 115.6,187.85 v2(122.81,187.85)
  BOTTOM w0.381: C466.2 250.91,180.95 v2(252.86,182.89) ; v2(249.68,175.15) 249.68,176.57 250.01,176.9
  BOTTOM w0.508: C466.2 250.91,177.97 250.94,177.94 C457.1 250.31,177.21 250.01,176.9
