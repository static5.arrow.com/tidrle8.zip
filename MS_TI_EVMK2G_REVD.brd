# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N14120305: length 3
  TOP w0.127: LD11.2 v2(24.38,249.4)
  BOTTOM w0.127: R592.2 v2(24.38,249.4)
N14152075: length 24.6
  TOP w0.102: U20.P19 80.21,194.23 80.61,193.82
  TOP w0.127: 80.61,193.82 80.78,193.65 80.78,192.46 81.98,191.26 84.85,191.26 85.6,190.51 95,190.51 95.76,191.28 99.31,191.28 100.84,189.75
N14152267: length 13.4
  TOP w0.127: v1(81.71,196.99) 81.97,197.25 C91.1 ; U20.H16 77.63,197.23 v1(77.19,196.79) ; U20.E10 75.05,198.73 v1(75.44,199.12)
  BOTTOM w0.102: v1(75.44,199.12) 75.87,199.12 76.58,198.41 76.58,197.75 77.19,197.14 v1(77.19,196.79) 77.62,197.22 77.99,197.22 78.07,197.15 78.84,197.15 80.01,195.98 80.9,195.98
  BOTTOM w0.127: C425.2 81.97,197.25 v1(81.71,196.99) 81.71,196.31 81.38,195.98 80.9,195.98
N16781633: length 8.1
  TOP w0.127: U53.3 43.76,78.17 42.62,79.31 v2(42.62,79.39) 42.62,80.31 R721.1 ; R426.1 v2(46.05,79.57)
  L03_SIG1 w0.127: v2(46.05,79.57) 42.8,79.57 v2(42.62,79.39)
N16781680: length 3
  TOP w0.127: Q12.3 42.02,82.32 42.54,81.79 R721.2
N16781762: length 3.6
  TOP w0.127: U53.6 42.76,73.83 v2(41.22,72.29)
  BOTTOM w0.127: R725.2 v2(41.22,72.29)
N16781794: length 3.2
  TOP w0.127: R456.2 42.75,72.46 43.26,72.97 U53.7
N16801982: length 2.8
  TOP w0.127: U93.12 29.04,128.34 28.78,128.08 R547.1
N16801984: length 2.7
  TOP w0.127: U93.11 R542.2
N16802002: length 2.8
  TOP w0.127: U93.6 v2(39.57,129.61)
  BOTTOM w0.127: v2(39.57,129.61) 39.19,129.99 C675.2
N16802018: length 3
  TOP w0.127: U93.1 v2(39.57,123.26)
  BOTTOM w0.127: C688.2 38.95,123.88 v2(39.57,123.26)
N16802020: length 3
  TOP w0.127: U93.3 v2(39.57,125.8)
  BOTTOM w0.127: C688.1 38.95,125.18 v2(39.57,125.8)
N16802026: length 2.8
  TOP w0.127: U93.5 v2(39.57,128.34)
  BOTTOM w0.127: C680.2 38.39,128.34 v2(39.57,128.34)
N16802028: length 2.8
  TOP w0.127: U93.4 v2(39.57,127.07)
  BOTTOM w0.127: C680.1 38.42,127.07 v2(39.57,127.07)
N16802060: length 2.6
  TOP w0.127: U93.2 C331.1
N16863485: length 3.6
  TOP w0.102: U27.H8 136.87,175.67 136.87,174.88 137.11,174.64 v2(137.79,174.64)
  BOTTOM w0.127: R693.2 137.54,174.39 v2(137.79,174.64)
N16909238: length 4.2
  TOP w0.102: v2(138.18,158.14) 136.88,159.44 136.88,160.44 U39.H8
  BOTTOM w0.127: R704.2 v2(138.18,158.14)
N16911821: length 3.9
  TOP w0.102: v1(137.72,143.47) 136.86,144.33 136.86,145.18 U45.H8
  BOTTOM w0.127: v1(137.72,143.47) 137.29,143.04 R712.2
N16958621: length 8.2
  TOP w0.127: C239.2 142.62,99.2 142.98,98.85 142.98,95.91 143.76,95.12 143.76,94.71 144.25,94.22 U62.40
N16958654: length 5.1
  TOP w0.127: U62.45 141.75,94.29 140.78,95.26 138.94,95.26 TP158.1
N16974283: length 1.9
  TOP w0.127: R461.2 C238.1
N17012640: length 8.5
  TOP w0.127: Y7.2 197.42,90.44 C278.1 200.29,92.93 200.57,93.21 U56.6
N17012642: length 8.8
  TOP w0.127: Y7.1 204.91,91.65 203.54,93.02 C271.1 202.44,93.66 202.13,93.97 202.13,94.78 201.89,95.02 U56.7
N17104917: length 17.4
  TOP w0.127: v2(184.05,246.83) 184.02,246.85 J2.35 ; TP17.1 v2(185.17,233.06)
  L08_SIG2 w0.127: v2(184.05,246.83) 184.05,246.68 183.71,246.34 183.71,233.91 184.24,233.37 184.85,233.37 v2(185.17,233.06)
N17104924: length 17.9
  TOP w0.127: v2(181.79,246.9) 182.12,247.23 182.63,247.23 182.75,247.36 J2.39 ; TP18.1 v2(183.13,232.93)
  L08_SIG2 w0.127: v2(181.79,246.9) 183.38,245.32 183.38,233.68 183.13,233.44 v2(183.13,232.93)
N17105134: length 8.9
  TOP w0.127: J2.62 175.77,238.27 175.27,237.77 175.27,232.54 TP14.1
N17105148: length 10.2
  TOP w0.127: J2.48 180.21,239.03 180.87,238.37 181.51,238.37 182.25,237.63 182.25,233.31 TP15.1
N17105158: length 12.3
  TOP w0.127: TP16.1 178.82,233.06 179.45,233.69 181.36,233.69 181.9,234.24 181.9,237.59 181.48,238.01 180.7,238.01 179.58,239.13 J2.50
N17108888: length 8.2
  TOP w0.127: R94.2 250.29,64.77 248.45,62.93 248.45,60.45 247.42,59.42 U17.A18
N17108899: length 7.9
  TOP w0.127: R88.2 240.79,64.66 241.55,63.9 241.55,60.78 240.22,59.45 240.22,58.84 U17.A9
N17108922: length 10
  TOP w0.127: U17.B15 v1(245.42,58.05)
  L08_SIG2 w0.102: 247.93,60.75 247.93,60.64 247.01,59.73 247.01,59.64 v1(245.42,58.05)
  L08_SIG2 w0.127: 247.93,60.75 247.93,62.75 v2(247.24,63.44)
  BOTTOM w0.127: v2(247.24,63.44) 247.24,64.05 246.48,64.81 246.48,65.24 246.27,65.46 R616.2
N17108924: length 8.7
  TOP w0.127: U17.B9 240.61,58.04 240.61,59.1 242.11,60.59 242.11,65.25 R618.2
N17109149: length 11.1
  TOP w0.127: U17.E9 v1(239.82,55.65)
  BOTTOM w0.127: v1(239.82,55.65) 239.42,56.05 239.42,61.97 240.66,63.21 R90.1
N17109151: length 8.3
  TOP w0.127: R89.1 244.2,65.27 242.44,63.51 242.44,59.87 U17.A10
N17109206: length 9
  TOP w0.127: R93.2 248.77,64.73 248.13,64.1 248.13,60.77 246.23,58.87 246.23,58.05 U17.B16
N17109930: length 20.6
  TOP w0.127: U17.C8 v1(239.02,57.25)
  BOTTOM w0.102: 239.01,59.68 239.02,59.67 239.02,59.28 238.92,59.18 237.95,59.18 237.85,59.07 237.85,58.87 237.95,58.77 238.92,58.77 239.02,58.67 239.02,57.33
  BOTTOM w0.127: 239.01,59.68 239.14,59.81 239.14,60.06 239.01,60.19 238.06,60.19 237.93,60.31 237.93,60.57 238.06,60.7 239.01,60.7 239.14,60.82 239.14,61.08 239.01,61.2 238.06,61.2 237.93,61.33 237.93,63.35 238.06,63.48 239.19,63.48 239.32,63.35 239.32,63.02 239.44,62.89 239.7,62.89 239.82,63.02 239.82,63.35 239.95,63.48 240.26,63.48 240.39,63.6 240.39,63.86 240.26,63.98 238.06,63.98 237.93,64.11 237.93,64.37 238.05,64.48 238.99,64.48 239.14,64.63 R619.2 ; 239.02,57.33 v1(239.02,57.25)
N17109932: length 8.4
  TOP w0.127: U17.A5 237.02,59.6 236.14,60.47 236.14,63.15 236.19,63.2 236.19,63.22 236.71,63.74 236.71,65.08 237.08,65.46 R620.2
N17110905: length 8.9
  TOP w0.127: R86.2 239.27,64.48 238,63.21 238,61.25 239.01,60.24 239.01,58.19 239.02,58.18 239.02,58.05 U17.B7
N17110913: length 11.2
  TOP w0.127: U17.D8 v1(239.02,56.45)
  BOTTOM w0.127: R87.2 237.6,65.47 237.03,65.47 236.83,65.27 236.83,59.19 238.62,57.4 238.62,56.85 v1(239.02,56.45)
N17110918: length 8
  TOP w0.127: U17.A16 245.82,58.97 247.76,60.91 247.76,63.93 247.24,64.45 R92.2
N17113205: length 4.6
  TOP w0.127: U17.V2 234.21,44.44 234.21,41.67 234.54,41.34 R189.2
N17118481: length 4
  TOP w0.127: v2(246.9,111.15) R110.2 TP41.1
  BOTTOM w0.127: R110.2 v2(246.9,111.15)
N17118483: length 3.5
  TOP w0.127: v2(249.19,111.15) R104.2 TP39.1
  BOTTOM w0.127: R104.2 v2(249.19,111.15)
N17118485: length 3.5
  TOP w0.127: v2(242.84,111.03) R121.2 TP46.1
  BOTTOM w0.127: R121.2 v2(242.84,111.03)
N17118487: length 3.5
  TOP w0.127: TP44.1 R114.2 v2(245,111.15)
  BOTTOM w0.127: R114.2 v2(245,111.15)
N17119674: length 6.1
  TOP w0.127: J1.4 259.64,11.98 263.59,11.98 R34.2
N17124284: length 16
  TOP w0.127: U1.AC19 v1(165.21,113.81)
  BOTTOM w0.127: C234.1 156.36,110.71 ; 156.36,110.71 156.21,110.86 155.82,110.86 155.46,110.5 154.56,110.5 154.39,110.67 153.2,110.67 152.95,110.42 Y6.1 ; 156.36,110.71 156.36,110.79 156.46,110.89 157.48,110.89 158.62,112.03 162.81,112.03 163.83,113.04 164.21,113.04 164.98,113.81 v1(165.21,113.81)
N17124300: length 12.6
  TOP w0.102: U1.AE19 v1(163.61,113.81)
  BOTTOM w0.127: 156.36,111.32 156.36,111.26 156.46,111.17 157.2,111.17 158.34,112.31 162.52,112.31 163.61,113.39 v1(163.61,113.81) ; 156.36,111.32 C232.1 ; 156.36,111.32 156.27,111.23 155.78,111.23 155.78,111.22 155.35,110.78 154.81,110.78 154.65,110.95 Y6.3
N17138453: length 3.7
  TOP w0.127: R113.1 247.27,105.52 247.22,105.47 U12.26
N17150258: length 7.2
  TOP w0.203: 222.68,72.84 J19.12
  TOP w0.381: R879.2 218.82,71.9 219.2,72.28 222.12,72.28 222.68,72.84
N17177920: length 6.3
  TOP w0.127: U20.W4 70.43,190.23 70.43,188.94 v2(69.85,188.36) 69.72,188.23 R667.1
  BOTTOM w0.127: R667.1 68.98,188.36 v2(69.85,188.36)
N17193198: length 2
  TOP w0.127: R32.1 LD7.2
N17193212: length 2.5
  TOP w0.127: LD8.1 Q7.3
N17193213: length 2.6
  TOP w0.127: LD7.1 Q6.3
N17193222: length 1.9
  TOP w0.127: R31.1 LD6.2
N17217348: length 5.1
  TOP w0.127: R781.2 223.66,70.9 224.18,71.42 J19.6
N17217726: length 1.7
  TOP w0.127: R314.2 C168.1
N17219428: length 5.4
  TOP w0.127: R342.2 219.96,84.06 220.32,83.71 221.17,83.71 221.68,83.2 J19.15
N17224206: length 1.9
  TOP w0.127: LD8.2 R33.1
N17253655: length 2.2
  TOP w0.127: R116.2 226.35,58.69 225.97,59.07 TP43.1
N17253657: length 9.5
  TOP w0.127: R116.1 229.9,58.69 232.13,56.45 236.63,56.45 U17.C5
N17253714: length 2
  TOP w0.127: TP49.1 225.97,55.51 226.02,55.56 R128.2
N17253716: length 8.1
  TOP w0.127: U17.E4 235.83,54.85 230.81,54.85 230.1,55.56 R128.1
N17253732: length 8.2
  TOP w0.127: R120.1 229.64,60.21 232.64,57.22 235.05,57.22 U17.C3
N17253734: length 2.3
  TOP w0.127: TP45.1 225.91,60.21 R120.2
N17253750: length 8.4
  TOP w0.127: U17.D4 235.84,55.67 231.39,55.67 229.97,57.09 R124.1
N17253752: length 2.1
  TOP w0.127: R124.2 226.17,57.09 225.97,57.29 TP47.1
N17255053: length 19.2
  TOP w0.127: U17.F16 v1(246.22,54.85) ; R127.1 v2(261.59,55.18)
  L08_SIG2 w0.102: 250.98,55.59 249.94,55.59 249.48,56.05 247.42,56.05 v1(246.22,54.85)
  L08_SIG2 w0.127: v2(261.59,55.18) 259.49,57.29 255.04,57.29 253.34,55.59 250.98,55.59
N17255055: length 2.3
  TOP w0.127: R127.2 264.8,55.18 TP48.1
N17255071: length 17.6
  TOP w0.127: R130.1 v2(261.5,53.66) ; U17.F17 v1(247.02,54.85)
  L08_SIG2 w0.102: 250.98,54.24 250.85,54.24 249.86,55.23 247.41,55.23 v1(247.02,54.85)
  L08_SIG2 w0.127: v2(261.5,53.66) 261.06,53.66 261.03,53.69 260.07,53.69 259.26,52.87 258.5,52.87 257.12,54.24 250.98,54.24
N17255073: length 2.1
  TOP w0.127: TP50.1 265.28,53.66 R130.2
N17255146: length 15.5
  TOP w0.127: U17.G19 248.65,53.65 v1(248.84,53.46) ; R136.1 v2(261.54,52.14)
  L08_SIG2 w0.102: 250.98,53.05 249.25,53.05 v1(248.84,53.46)
  L08_SIG2 w0.127: v2(261.54,52.14) 261.1,52.14 260.92,52.31 258.37,52.31 257.05,53.63 254.61,53.63 254.03,53.05 250.98,53.05
N17255876: length 11.1
  TOP w0.127: R158.1 251.63,45.47 249.45,47.64 246.23,47.64 U17.P16
N17277948: length 10.3
  TOP w0.381: FL8.3 96.77,97.42 96.15,96.8 C296.1 97.03,93.87 97.08,93.81 v2(97.36,93.81) U78.2
  BOTTOM w0.381: v2(97.36,93.81) 97.86,93.81 98.04,93.99 C665.2
N17278529: length 3.9
  TOP w0.127: U78.5 v2(104.07,92.51)
  BOTTOM w0.127: C666.1 101.4,92.51 v2(104.07,92.51)
N17278696: length 10.8
  TOP w0.127: U79.2 109.42,95.02 108.69,95.75 106.4,95.75 106.05,95.39 C303.1 U78.6
N17279260: length 11.2
  TOP w0.381: U79.1 C292.1 111.14,96.65 111.51,96.28 111.51,94.12 111.77,93.85 C293.2 112.78,93.11 112.17,92.5 FL9.3
N17280261: length 7.6
  TOP w0.381: FL7.3 119.79,96.84 120.27,96.36 C272.2 C273.1 122.47,95.41 122.96,95.9 U60.9
N17280894: length 16.6
  TOP w0.127: U17.B18 247.83,58.05 250.49,58.05 251.05,58.61 253.72,58.61 254.74,59.63 260.45,59.63 261.85,58.23 R119.1
N17280896: length 16.7
  TOP w0.127: U17.B19 250.11,57.65 250.2,57.56 253.55,57.56 255.24,59.25 260.32,59.25 261.71,57.86 261.71,56.97 261.98,56.71 R123.1
N17286145: length 9.1
  TOP w0.127: U17.T18 247.82,46.05 247.82,39.93 TP65.1
N17286149: length 11.5
  TOP w0.127: R185.1 246.1,38.55 246.48,38.17 TP82.1 247.04,38.85 247.04,46.03 U17.T17
N17289768: length 29.2
  TOP w0.127: R650.2 R167.2 R156.2 v2(264.99,47.56) ; U17.K14 v1(244.62,51.65)
  L08_SIG2 w0.102: 250.98,48.35 250.57,48.35 249.66,49.27 248.95,49.27 248.55,49.67 244.46,49.67 244.24,49.89 244.24,50.63 244.62,51.01 v1(244.62,51.65)
  L08_SIG2 w0.127: v2(264.99,47.56) 264.45,47.56 263.42,46.54 259.72,46.54 258.69,47.56 254.29,47.56 253.51,48.35 250.98,48.35
N17289805: length 2.2
  TOP w0.127: R149.1 v2(264.99,49.09)
  BOTTOM w0.127: R149.1 v2(264.99,49.09)
N17289822: length 17.9
  TOP w0.127: U17.J17 v1(247.02,52.45)
  BOTTOM w0.127: v1(247.02,52.45) 251.45,52.45 252.4,51.5 257.1,51.5 257.53,51.93 257.53,51.96 257.82,52.25 257.85,52.25 257.86,52.26 260.32,52.26 261.21,51.37 262.47,51.37 262.6,51.25 R640.1
N17291112: length 7.3
  TOP w0.127: R486.1 R487.1 C277.1 123.42,91.98 124.21,92.76 U60.10
N17296373: length 9.5
  TOP w0.127: U17.T19 248.77,45.9 248.77,40.81 TP57.1
N17428402: length 1.2
  TOP w0.127: U1.H7 v1(177.21,124.21)
  BOTTOM w0.102: R719.1 177.47,124.48 v1(177.21,124.21)
N17473267: length 4.5
  TOP w0.127: U82.L1 129.65,66.52 129.65,67.01 130.05,67.4 131.14,67.4 131.62,67.88 R509.1
N17484568: length 2.3
  TOP w0.127: U115.2 295.52,51.41 295.52,51.41 R813.2
N17556024: length 3.9
  TOP w0.203: v2(246.76,177.69) 246.47,177.4 U32.A6
  TOP w0.381: v2(246.76,178.4) v2(246.76,177.69)
  BOTTOM w0.33: R670.1 247.49,178.83 247.24,178.83 246.78,178.37 246.76,178.4
  BOTTOM w0.381: v2(246.76,177.69) v2(246.76,178.4)
N17556030: length 3.9
  TOP w0.127: U32.A4 245.17,180.6 244.96,180.81
N17556082: length 6.4
  TOP w0.102: 244.19,176.69 U32.B3
  TOP w0.127: 244.19,176.69 243.64,176.69 243.51,176.83 243.51,177.14 243.23,177.41 243.23,179.34 242.44,180.13 R244.1
N17556602: length 5.2
  TOP w0.102: 244.35,179.97 244.42,179.9 244.42,179.44 243.81,178.83 243.81,177.64 243.87,177.59 U32.A2
  TOP w0.127: 244.35,179.97 244.14,180.18 C452.1
N17556776: length 12.7
  TOP w0.381: 244.58,187.78 U22.3 ; 244.58,187.78 244.35,187.55 v2(244.35,186.96) ; 244.58,187.78 243.95,187.78 v2(243.66,187.49)
  BOTTOM w0.381: v2(244.35,186.96) 244.86,186.96 245.24,187.34 ; 245.24,187.34 244.86,187.72 243.89,187.72 v2(243.66,187.49) ; 245.24,187.34 245.87,186.7 245.87,183.02 246.38,182.51 R671.2
N17556786: length 1.7
  TOP w0.254: 242.78,175.07 U32.D1 U32.D2 U32.E2
N17556798: length 3.5
  TOP w0.254: U32.H2 U32.H1 241.41,172.47 240.66,171.72
N17556884: length 3.7
  TOP w0.203: v2(244.22,177.81) 244.52,177.52 U32.A3
  BOTTOM w0.381: v2(244.22,177.81) 245.78,179.37 R671.1
N17556932: length 2.9
  TOP w0.102: U32.C5 v1(245.49,175.39)
  BOTTOM w0.127: C451.1 246.93,175.87 246.45,175.39 v1(245.49,175.39)
N17557226: length 24.4
  TOP w0.102: U32.C6 246.79,176.04 246.79,177.15 247.38,177.74 247.38,178.18 v2(247.47,178.27)
  L03_SIG1 w0.127: v2(247.47,178.27) 247.4,178.35 247.4,179.34 250.19,182.13 263.07,182.13 265.1,184.16 TP91.1
N17557396: length 20.6
  TOP w0.102: 248.82,175.39 246.14,175.39 U32.D5
  TOP w0.127: 248.82,175.39 250.25,176.82 253.82,176.82 254.23,176.42 257.18,176.42 257.87,177.12 257.87,178.87 258.04,179.03 258.88,179.03 259.33,178.58 261.62,178.58 262,178.96 TP102.1
N17557440: length 1.6
  TOP w0.254: 248.67,170.96 248.46,171.17 U32.K8 U32.K7
N17557462: length 8.2
  TOP w0.381: 248.26,186.55 v2(247.65,185.94) ; 248.26,186.55 248.26,187.1 U22.5 ; 248.26,186.55 248.41,186.4 v2(248.41,185.94)
  BOTTOM w0.381: 248.03,185.43 247.78,185.69 247.78,185.82 v2(247.65,185.94) ; 248.03,185.43 248.03,185.56 v2(248.41,185.94) ; 248.03,185.43 R670.2
N17557538: length 7.5
  TOP w0.127: v2(250.19,174.59) 249.75,174.59 249.57,174.42 U32.E8
  BOTTOM w0.127: v2(250.19,174.59) 249.88,174.27 249.88,173.57 250.25,173.19 250.25,171.01 250.99,170.27 R692.2
N17601404: length 5.5
  TOP w0.127: D2.4 v2(290.87,104.2)
  BOTTOM w0.127: R599.1 290.55,105.78 290.87,105.46 v2(290.87,104.2) 289.43,104.2 R600.2
N17601690: length 2.8
  TOP w0.127: U2.3 290.87,100.64 290.57,100.94 U4.4
N17601710: length 3
  TOP w0.127: v2(294.74,99.56) 294.74,100 294.73,100.01 294.73,100.55 U2.4
  BOTTOM w0.127: v2(294.74,99.56) 294.74,100 294.5,100.24 C363.1
N17734901: length 11.9
  TOP w0.127: C14.1 v2(137.17,230.5) 137.17,227.74 136.45,227.01 L1.1 136.4,223.96
  BOTTOM w0.127: v2(137.17,230.5) 138.32,230.5 138.89,229.94 D5.1
  vias: v2(138.81,231.05) v2(139.8,231.05) v2(140.77,231.1) v2(141.55,229.86) v2(141.58,228.67) v2(141.58,227.5)
N17856438: length 3.4
  TOP w0.127: U27.A7 143.54,176.85 144.81,175.58 TP106.1
N17856470: length 3.3
  TOP w0.127: TP115.1 144.5,160.34 143.23,161.61 U39.A7
N17856498: length 3.2
  TOP w0.127: TP123.1 144.45,145.25 143.76,145.94 143.28,145.94 U45.A7
N17944399: length 29.1
  TOP w0.127: v2(185.85,146.06) 186.25,146.46 186.25,146.61 TP125.1 ; U1.J3 v1(176.41,127.41)
  L03_SIG1 w0.102: v1(176.41,127.41) 176.23,127.6 176.23,129.63 176.53,129.94 176.53,133.7 177.42,134.58 177.42,134.89
  L03_SIG1 w0.127: 177.42,134.89 177.48,134.95 177.48,137.62 178.36,138.5 179.68,138.5 181.74,140.55 181.74,145.61 182.07,145.94 185.73,145.94 v2(185.85,146.06)
  BOTTOM w0.127: R347.2 186.61,146.83 v2(185.85,146.06)
N17944408: length 32.3
  TOP w0.127: v1(175.62,130.49) 175.61,130.49 175.61,128.21 U1.K2 ; v2(182.12,146.4) 182.12,149.21 181.38,149.95 181.33,149.95 180.11,151.17 180.11,151.7 181.2,152.8 181.2,154.27 TP124.1
  L03_SIG1 w0.102: 176.15,134.89 176.15,134.43 176,134.28 176,130.88 v1(175.62,130.49)
  L03_SIG1 w0.127: 176.15,134.89 177.24,135.98 177.24,137.97 178.09,138.83 179.5,138.83 181.36,140.68 181.36,145.64 v2(182.12,146.4)
N18024893: length 17.8
  TOP w0.127: U14.7 v2(67.89,208.4) ; R153.1 v2(80.65,206.86)
  L03_SIG1 w0.127: v2(67.89,208.4) 68.3,208.8 79.76,208.8 80.65,207.91 v2(80.65,206.86)
  BOTTOM w0.127: R153.1 v2(80.65,206.86)
N18029281: length 6.6
  TOP w0.102: 72.43,200.93 71.29,202.07
  TOP w0.127: R170.2 67.67,203.34 68.94,202.07 71.29,202.07 ; U20.A5 72.43,200.93
N18029296: length 8.6
  TOP w0.102: 71.43,202.31 72.71,201.03 72.71,200.51 U20.B5
  TOP w0.127: 71.43,202.31 69.28,202.31 68.07,203.52 68.07,204.33 67.64,204.76 R177.2
N18031024: length 3.7
  TOP w0.127: U10.3 120.84,226.14 120.14,226.84 R109.1
N18055312: length 6.2
  TOP w0.254: TP169.1 270.94,34.86 270.76,35.04 270.76,38.58 271.58,39.39 U96.7
N18055326: length 6.3
  TOP w0.254: TP170.1 272.75,35.24 271.91,36.08 271.48,36.08 271.2,36.36 271.2,38.47 271.61,38.89 U96.8
N18055702: length 8.8
  TOP w0.254: U96.19 275.84,35.45 276.06,35.23 276.06,34.34 276.86,33.54 276.86,28.72 TP172.1
N18055705: length 8.4
  TOP w0.254: TP173.1 277.34,28.74 U96.22
N18067178: length 2.8
  TOP w0.127: U95.6 294.08,41.46 294.51,41.9 R558.1
N18067322: length 5
  TOP w0.127: U95.5 294.73,40.8 294.84,40.91 295.53,40.91 295.77,40.67 R563.1 R564.2
N18068201: length 6.4
  TOP w0.127: U96.35 280.25,41.89 280.8,42.43 284,42.43 284.35,42.08 TP168.1
N18068219: length 3.4
  TOP w0.127: U96.34 281.65,41.39 281.75,41.29 TP167.1
N18091435: length 14.1
  TOP w0.127: U86.2 v2(8.04,43.58) ; v2(8.04,43.58) 8.04,40.7 7.56,40.21 SW12.2 ; v2(8.04,43.58) 8.04,46.41 8.38,46.75 R435.1
  BOTTOM w0.127: v2(8.04,43.58) 9.23,43.58 9.65,43.15 R749.1
N18114221: length 11.6
  TOP w0.127: TP182.1 85.79,197.86 v2(85.3,198.34) ; v1(77.93,198.77) 77.93,198.73 U20.F17
  L03_SIG1 w0.102: 80.9,199.42 79.54,199.42 78.89,198.77 v1(77.93,198.77)
  L03_SIG1 w0.127: v2(85.3,198.34) 84.49,199.15 81.92,199.15 81.65,199.42 80.9,199.42
N18124845: length 2.2
  TOP w0.127: v2(179.95,198.84) U34.5
  BOTTOM w0.127: R694.2 179.68,199.11 v2(179.95,198.84)
N18144573: length 8
  TOP w0.127: R316.1 87.11,166.27 87,166.38 87,168.04 87.3,168.34 v2(87.92,168.34) U35.2
  BOTTOM w0.127: v2(87.92,168.34) 87.48,168.34 87.25,168.12 87.25,166.38 87.36,166.27 R316.1
N18147498: length 3.9
  TOP w0.127: R310.1 59.07,170.11 59.21,170.25 v2(59.98,170.25) U33.2
  BOTTOM w0.127: R310.1 59.07,170.11 59.21,170.25 v2(59.98,170.25)
N18151943: length 4.4
  TOP w0.127: R255.1 86.98,179.59 v2(87.67,180.28) U24.2
  BOTTOM w0.127: v2(87.67,180.28) 86.52,180.28 86.37,180.14 R255.1
N18158148: length 5.2
  TOP w0.127: R280.1 70.26,175.4 70.44,175.58 v2(71.5,175.58) 71.55,175.63 U30.2
  BOTTOM w0.127: R280.1 70.26,175.4 70.44,175.58 v2(71.5,175.58)
N18158579: length 6
  TOP w0.127: R290.1 69.61,174.4 69.85,174.64 70.39,174.64 v2(70.73,174.98) U30.3
  BOTTOM w0.127: R290.1 69.61,174.4 69.85,174.64 70.39,174.64 v2(70.73,174.98)
N18163620: length 9.1
  TOP w0.102: 72.07,191.44 72.21,191.58 72.21,191.95 U20.V4
  TOP w0.127: 72.07,191.44 70.71,190.08 70.71,188.38 v2(69.85,187.52) 69.85,186.96 69.6,186.7 R232.1
  BOTTOM w0.127: R232.1 69.6,186.7 69.85,186.96 v2(69.85,187.52)
N18168142: length 3.8
  TOP w0.127: v2(177.81,92.08) 177.02,91.29 R498.1
  BOTTOM w0.127: U66.10 v2(177.81,92.08) 177.42,92.47 177.42,92.72 177.52,92.83 U66.1
N18192341: length 4.4
  TOP w0.127: R596.2 R595.2 206.91,222.01 206.92,222.02 J5.B17
N18211886: length 4.3
  TOP w0.127: R65.2 R66.2 221.94,244.26 222,244.32 U5.1
N18211953: length 13.3
  TOP w0.127: U131.2 224.54,249.29 224.38,249.44 v2(222.76,249.44) ; U5.4 v2(225.35,241.19)
  L03_SIG1 w0.127: v2(222.76,249.44) 223.65,248.55 223.65,242.9 v2(225.35,241.19)
N18214699: length 2.5
  TOP w0.127: J5.A11 v2(216.32,228.91)
  BOTTOM w0.127: v2(216.32,228.91) 216.93,229.52 R606.1
N18323233: length 1.8
  TOP w0.127: R323.2 U41.21
N18323302: length 2.9
  TOP w0.127: U41.2 226.19,101.56 227.24,102.62 R353.1
N18887648: length 3.7
  BOTTOM w0.127: C384.2 54.61,225.94 53.43,224.76 MOD1.8
N18887654: length 5.3
  BOTTOM w0.127: C384.1 55.16,228.46 55.37,228.24 55.37,225.39 54.93,224.95 MOD1.9
N18887823: length 5.6
  BOTTOM w0.127: MOD1.7 53.21,225.28 53.21,228.24 53,228.46 C385.2
N18887827: length 4
  BOTTOM w0.127: MOD1.6 52.45,226.02 C385.1
N19207451: length 25.7
  TOP w0.102: U1.M21 v1(174.81,112.21)
  TOP w0.127: v2(185.78,93.16) 186.09,92.84 186.09,92.15 TP127.1
  L08_SIG2 w0.102: v1(174.81,112.21) 175.21,111.81 175.21,110.35 176.07,109.49 176.39,109.49 177.55,108.33 177.55,107.89 178.59,106.85 178.59,106.43 180.07,104.95 180.45,104.95 181.37,104.03
  L08_SIG2 w0.127: 181.37,104.03 181.64,103.76 181.64,98.72 181.71,98.65 181.71,98.57 185.78,94.5 v2(185.78,93.16)
N19207912: length 18.1
  TOP w0.127: U1.C17 v1(182.01,116.21)
  BOTTOM w0.127: Y5.3 196.13,116.42 195.93,116.22 193.9,116.22 193.65,115.97 192.66,115.97 192.53,116.09 ; v1(182.01,116.21) 183.01,117.21 184.68,117.21 185.47,118 189.28,118 190.45,116.83 191.06,116.83 191.92,115.97 192.41,115.97 192.53,116.09 ; 192.53,116.09 C223.2
N19207996: length 14.1
  TOP w0.127: v1(183.77,115.97) 183.62,115.81 U1.A17
  BOTTOM w0.127: 192.53,115.49 192.63,115.58 193.26,115.58 193.73,115.12 Y5.1 ; 192.53,115.49 192.33,115.69 191.81,115.69 190.94,116.55 190.33,116.55 189.19,117.69 185.5,117.69 184.56,116.75 184.25,116.75 183.77,116.27 v1(183.77,115.97) ; 192.53,115.49 C220.2
N19208525: length 23.5
  TOP w0.127: U1.K1 176.01,129.21 176.07,129.28 176.07,131.96 v1(175.61,132.42) ; v2(177.39,148.66) 176.55,148.66 TP135.1
  L08_SIG2 w0.127: v1(175.61,132.42) 175.21,132.82 175.21,133.96 176.08,134.83 176.08,135.33 177.42,136.67 177.42,139.17 178.4,140.15 178.4,143.06 178.74,143.4 178.74,145.96 177.39,147.31 v2(177.39,148.66)
N19208527: length 25.1
  TOP w0.127: v2(178.21,145.73) 177.9,146.04 177.9,146.14 177.62,146.42 177.14,146.42 175.65,147.91 175.65,150.04 TP131.1 ; U1.L1 175.21,130.75 v1(175.61,131.15)
  L08_SIG2 w0.102: v1(175.61,131.15) 174.92,131.85 174.92,134.47
  L08_SIG2 w0.127: 174.92,134.47 174.83,134.56 174.83,137.63 177.29,140.1 177.29,140.86 177.92,141.48 177.92,145 178.21,145.29 v2(178.21,145.73)
N19208590: length 20.3
  TOP w0.127: U1.D24 181.21,109.81 v1(181.21,108.14) ; v2(188.49,97.87) 188.81,97.55 189.72,97.55 TP132.1
  BOTTOM w0.127: v2(188.49,97.87) 188.47,97.89 188.47,99.46 188.16,99.76 186.26,99.76 181.83,104.19 181.8,104.19 181.1,104.89 179.73,104.89 179.59,105.03 179.59,106.2 180.39,107 180.39,107.33 v1(181.21,108.14)
N19209091: length 20.5
  TOP w0.127: U1.D20 v1(181.21,113.81)
  L08_SIG2 w0.102: v1(181.21,113.81) 181.6,113.43 187.4,113.43 187.77,113.79 189.1,113.79
  L08_SIG2 w0.127: v2(199.12,112.28) 198.68,112.28 198.55,112.41 197.03,112.41 195.64,113.79 189.1,113.79
  BOTTOM w0.127: v2(199.12,112.28) 199.14,112.28 199.64,112.79 R442.2
N19209222: length 21.2
  TOP w0.127: U1.C19 v1(182.01,114.61) ; R431.2 v2(200.01,110.4)
  L03_SIG1 w0.102: v1(182.01,114.61) 183.24,114.61 184.01,113.85 188.07,113.85 189.1,112.82
  L03_SIG1 w0.127: 189.1,112.82 189.95,111.97 195.52,111.97 196.71,110.77 199.64,110.77 v2(200.01,110.4)
N19209666: length 3.2
  BOTTOM w0.508: 188.37,16.5 J30.2 ; J30.2 189.43,15.43 ; J30.2 189.43,17.57
N19250103: length 3.7
  TOP w0.127: R523.2 141.59,54.57 141.01,53.98 SW13.1
N19351417: length 2.6
  TOP w0.127: J34.33 126.27,20.66 126.7,21.08 R579.1
N19351424: length 2.7
  TOP w0.127: R578.1 125.17,21.08 125.77,20.48 J34.35
N19354929: length 3.2
  TOP w0.127: U106.4 131.07,29.34 130.61,29.81 U140.2
N19355586: length 3.5
  TOP w0.127: TP174.1 133.27,10.94 J34.16
N19356463: length 9.2
  TOP w0.127: TP179.1 126.8,9.77 126.27,10.29 J34.34
N19364584: length 22.2
  TOP w0.127: U1.Y20 v1(168.41,113.01)
  BOTTOM w0.102: 162.87,104.03 162.87,104.59 163.83,105.55 163.83,107.84 165.61,109.62 165.61,110.78 165.84,111.01 166.22,111.01 166.4,111.19 166.4,111.55 167.45,112.6 167.81,112.6 168.22,113.01 v1(168.41,113.01)
  BOTTOM w0.127: 162.87,104.03 162.87,102.68 161.55,101.36 159.69,101.36 158.61,100.28 158.61,99.06 157.99,98.44 157.99,97.7 TP138.1
N19364586: length 24.5
  TOP w0.127: U1.AB19 v1(166.01,113.81)
  BOTTOM w0.102: 161.26,111.01 163.07,111.01 ; v1(166.01,113.81) 165.82,113.81 165.4,113.4 165.05,113.4 163.42,111.77 163.42,111.37 163.26,111.2
  BOTTOM w0.127: TP146.1 153.02,99.47 153.02,102.35 154.19,103.52 156.11,103.52 156.41,103.82 156.41,107.53 159.33,110.45 159.82,110.45 160.5,111.14 161.14,111.14 161.26,111.01 ; 163.07,111.01 163.26,111.2
N19364588: length 17.6
  TOP w0.127: U1.AA19 v1(166.81,113.81)
  BOTTOM w0.102: v1(166.81,113.81) 166.42,113.43 165.88,113.43 165.61,113.15 165.61,112.87 165.34,112.6 165.06,112.6 165.06,112.59 165.05,112.59 164.83,112.37 164.83,112.37 163.96,111.5 163.96,110.48 162.84,109.36 162.84,105.73 161.82,104.71 161.82,104.03
  BOTTOM w0.127: TP144.1 158.62,102.35 161.02,102.35 161.82,103.15 161.82,104.03
N19364600: length 20.6
  TOP w0.127: U1.W19 v1(168.41,113.81)
  BOTTOM w0.102: 162.57,104.03 162.57,104.68 163.58,105.69 163.58,109.01 164.8,110.23 164.8,110.78 165.01,111 165.33,111 165.61,111.27 165.61,111.55 165.86,111.8 166.14,111.8 167.01,112.67 167.01,112.97 167.44,113.4 168,113.4 v1(168.41,113.81)
  BOTTOM w0.127: 162.57,104.03 162.57,102.91 161.3,101.64 159.57,101.64 157.87,99.94 TP147.1
N19367736: length 15.5
  TOP w0.127: R482.2 196.09,124.75 195.84,124.75 194.44,123.34 190.33,123.34 190.22,123.46 184.35,123.46 183.51,122.61 182.81,122.61 U1.B9
N19367738: length 8.9
  TOP w0.127: R454.2 191.4,122.44 190.78,123.07 184.44,123.07 183.59,122.21 U1.A9
N19367748: length 15.4
  TOP w0.127: U1.B10 182.81,121.81 183.64,121.81 184.02,122.19 189.86,122.19 190.23,121.82 194.23,121.82 195.06,122.64 195.41,122.64 196.48,123.71 R451.2
N19367766: length 8.9
  TOP w0.127: R447.2 190.99,121.43 189.99,121.43 189.51,121.91 184.18,121.91 183.68,121.41 U1.A10
N19367768: length 16.6
  TOP w0.127: U1.C10 v1(182.01,121.81)
  L08_SIG2 w0.102: 189.1,121.81 v1(182.01,121.81)
  L08_SIG2 w0.127: v2(195.58,123.71) 195.58,122.52 194.87,121.81 189.1,121.81
  BOTTOM w0.127: R480.2 v2(195.58,123.71)
N19367778: length 21.8
  TOP w0.127: U1.E10 v1(179.61,121.01)
  L08_SIG2 w0.102: v1(179.61,121.01) 180.81,122.21
  L08_SIG2 w0.127: v2(195.58,126.76) 196.16,126.18 196.16,125.02 195.04,123.89 194.79,123.89 194.08,123.18 188.87,123.18 187.91,122.21 180.81,122.21
  BOTTOM w0.127: R476.2 v2(195.58,126.76)
N19367788: length 19.5
  TOP w0.127: U1.D10 v1(181.21,121.81)
  L03_SIG1 w0.102: v1(181.21,121.81) 181.61,122.21 183.74,122.21 184.53,121.43 188.59,121.43 189.1,120.92
  L03_SIG1 w0.127: 189.1,120.92 189.99,120.03 192.59,120.03 193.56,119.06 195.42,119.06 195.49,119.13 196.28,119.13 v2(197.15,118.25)
  BOTTOM w0.127: v2(197.15,118.25) 196.61,118.8 R472.2
N19367798: length 22
  TOP w0.127: U1.F10 v1(178.81,121.81)
  L08_SIG2 w0.102: v1(178.81,121.81) 179.2,122.2 179.2,124.42 179.37,124.6 182.47,124.6 184.28,126.41
  L08_SIG2 w0.127: 184.28,126.41 187.25,126.41 187.63,126.02 194.13,126.02 194.17,125.99 194.18,125.99 194.48,125.7 194.48,125.68 194.92,125.24 v2(195.58,125.24)
  BOTTOM w0.127: R469.2 v2(195.58,125.24)
N19367816: length 22.4
  TOP w0.127: R441.2 201.32,116 200.7,116 v2(200.25,115.56) ; U1.C11 v1(182.01,121.01)
  L03_SIG1 w0.102: v1(182.01,121.01) 184.21,121.01
  L03_SIG1 w0.127: 184.21,121.01 184.73,120.49 189.05,120.49 189.79,119.75 190.75,119.75 192.05,118.46 193.21,118.46 194.15,117.52 196.82,117.52 197.52,116.82 199,116.82 v2(200.25,115.56)
N19367818: length 23.5
  TOP w0.127: U1.D11 v1(181.21,121.01) ; R437.2 v2(200.25,114.52)
  L03_SIG1 w0.102: 184.28,120.18 183.85,120.61 181.86,120.61 181.46,121.01 v1(181.21,121.01)
  L03_SIG1 w0.127: 184.28,120.18 188.77,120.18 189.71,119.24 190.83,119.24 191.95,118.12 193.14,118.12 194.03,117.24 196.34,117.24 199.11,114.47 200.2,114.47 v2(200.25,114.52)
N19367846: length 19.2
  TOP w0.127: U1.E12 v1(179.61,119.41)
  L08_SIG2 w0.102: 189.1,121.5 182.58,121.5 182.5,121.43 180.85,121.43 180.21,120.79 180.21,120.02 v1(179.61,119.41)
  L08_SIG2 w0.127: v2(195.33,120.92) 194.74,121.5 189.1,121.5
  BOTTOM w0.127: R459.2 195.58,120.66 v2(195.33,120.92)
N19367848: length 16
  TOP w0.127: U1.C12 v1(182.01,120.21)
  BOTTOM w0.102: v1(182.01,120.21) 182.59,120.79 184.91,120.79 185.56,121.44 188.82,121.44 188.84,121.45 189.1,121.45
  BOTTOM w0.127: R481.2 194.39,122.19 194.16,121.96 193.52,121.96 193.24,121.68 190.5,121.68 190.27,121.45 189.1,121.45
N19367866: length 15.9
  TOP w0.127: R460.2 195.9,122.19 194.82,121.11 194.82,120.94 194.2,120.32 189.95,120.32 188.72,121.55 184.15,121.55 183.61,121.01 182.81,121.01 U1.B11
N19367868: length 15.6
  TOP w0.127: R477.2 196.42,120.66 195.81,120.06 194.46,120.06 194.18,119.78 194.18,119.58 193.73,119.13 190.58,119.13 190.28,119.43 189.71,119.43 188.8,120.33 183.82,120.33 183.7,120.21 182.81,120.21 U1.B12
N19367970: length 20.9
  TOP w0.127: U1.C7 v1(182.01,124.21)
  BOTTOM w0.102: 184,127.29 185.37,128.67 185.8,128.67
  BOTTOM w0.127: 184,127.29 182.87,127.29 182.6,127.03 182.6,124.68 182.14,124.21 v1(182.01,124.21) ; 185.8,128.67 188.82,128.67 189.66,127.83 193.47,127.83 193.74,128.09 194.48,128.09 194.69,128.31 194.69,129.63 195.49,130.43 195.57,130.43 196.47,131.33 R444.2
N19368123: length 9.3
  TOP w0.102: 189.1,124.59 188.99,124.59 188.9,124.68 185.23,124.68 183.57,123.01 U1.A8
  TOP w0.127: R468.2 191.4,123.97 190.78,124.59 189.1,124.59
N19368147: length 10.5
  TOP w0.127: U1.C8 v1(182.01,123.41)
  L03_SIG1 w0.102: v1(182.01,123.41) 189.1,123.41
  L03_SIG1 w0.127: v2(190.5,122.44) 189.53,123.41 189.1,123.41
  BOTTOM w0.127: R448.2 v2(190.5,122.44)
N19368179: length 13.3
  TOP w0.127: U1.E9 v1(179.61,121.81)
  L08_SIG2 w0.102: 184.78,123 180.8,123 v1(179.61,121.81)
  L08_SIG2 w0.127: 184.78,123 185.39,123.61 190.02,123.61 v2(190.37,123.97)
  BOTTOM w0.127: R470.2 v2(190.37,123.97)
N19368226: length 10.2
  TOP w0.102: 183.59,123.41 185.11,124.93 189.1,124.93
  TOP w0.127: 189.1,124.93 189.17,124.87 190.78,124.87 191.4,125.49 R473.2 ; U1.B8 182.81,123.41 183.59,123.41
N19368266: length 10.8
  TOP w0.127: U1.C9 v1(182.01,122.61)
  L03_SIG1 w0.102: v1(182.01,122.61) 184.59,122.61
  L03_SIG1 w0.127: 184.59,122.61 185.29,121.91 189.36,121.91 v2(190.35,120.92)
  BOTTOM w0.127: R458.2 v2(190.35,120.92)
N19368284: length 16.6
  TOP w0.127: U1.D9 v1(181.21,122.61) ; v2(191.26,117.34) 191.5,117.1 R452.2
  L03_SIG1 w0.102: 188.72,119.83 181.85,119.83 181.63,120.06 181.63,120.37 181.64,120.38 181.41,120.61 180.87,120.61 180.59,120.89 180.59,122 v1(181.21,122.61)
  L03_SIG1 w0.127: 188.72,119.83 189.64,118.91 190.75,118.91 191.26,118.4 v2(191.26,117.34)
N19368587: length 17.6
  TOP w0.127: R439.2 196.53,131.64 194.92,131.64 194.49,131.21 194.49,130.31 193.75,129.57 190.27,129.57 189.29,128.59 187.5,128.59 186.49,127.57 186.49,127.29 186.21,127.01 184.63,127.01 184.43,126.81 184.42,126.81 183.4,125.8 183.38,125.8 183.37,125.81 182.8,125.81 U1.B5
N19368605: length 16.4
  TOP w0.127: U1.B6 182.81,125.01 183.42,125.01 184.86,126.46 188.01,126.46 189.46,127.9 193.59,127.9 193.63,127.86 194.38,127.86 195.74,129.22 195.89,129.22 196.48,129.81 R434.2
N19368607: length 21.5
  TOP w0.127: R430.2 199.95,125.82 199.72,126.05 196.28,126.05 196.06,125.83 195.52,125.83 195.08,125.4 194.88,125.4 v2(194.28,124.81) ; U1.D7 v1(181.21,124.21)
  L03_SIG1 w0.127: v2(194.28,124.81) 189.84,124.81 188.85,123.81 181.61,123.81 v1(181.21,124.21)
N19368625: length 15.5
  TOP w0.102: U1.A6 183.62,124.61 185.2,126.19 188.16,126.19 189.1,127.14
  TOP w0.127: 189.1,127.14 189.59,127.62 193.52,127.62 193.53,127.61 193.99,127.61 194.56,127.04 195.1,127.04 195.63,127.57 195.63,127.82 196.1,128.28 R425.2
N19368627: length 24.2
  TOP w0.127: U1.C6 v1(182.01,125.01) ; R422.2 200.92,127.56 201.5,126.98 v2(201.5,127.03)
  L08_SIG2 w0.127: v1(182.01,125.01) 182.45,125.01 184.2,126.76 188.49,126.76 188.85,126.41 190.65,126.41 191.74,127.5 193.73,127.5 194.34,128.11 194.87,128.11 194.98,127.99 195,127.99 195.29,127.7 195.29,127.69 195.38,127.6 196.95,127.6 198.48,126.08 200.54,126.08 v2(201.5,127.03)
N19368645: length 25.9
  TOP w0.127: U1.E8 v1(179.61,122.61) ; R419.2 200.74,117.59 v2(199.67,118.66)
  L03_SIG1 w0.102: 180.88,123.01 180.49,122.61 v1(179.61,122.61)
  L03_SIG1 w0.127: v2(199.67,118.66) 199.59,118.73 198.86,118.73 198.5,119.09 198.5,119.62 196.74,121.39 195.09,121.39 194.15,120.45 193.66,120.45 192.46,121.66 190.2,121.66 188.87,122.98 187.25,122.98 187.19,123.03 185.58,123.03 185.56,123.01 181.4,123.01 181.4,123.01 180.88,123.01
N19368655: length 14.7
  TOP w0.102: U1.A7 183.57,123.81 184.91,125.16 188.06,125.16 188.14,125.24 189.1,125.24
  TOP w0.127: 189.1,125.24 189.36,125.24 190.1,125.98 190.37,125.98 190.64,126.25 194.52,126.25 194.7,126.44 195.08,126.44 195.22,126.3 196.02,126.3 196.48,126.76 R416.2
N19368657: length 11.7
  TOP w0.127: U1.D8 v1(181.21,123.41)
  L08_SIG2 w0.102: v1(181.21,123.41) 181.61,123.81 184.1,123.81 185.27,124.98 189.1,124.98
  L08_SIG2 w0.127: 189.1,124.98 189.99,124.98 v2(190.5,125.49)
  BOTTOM w0.127: R414.2 v2(190.5,125.49)
N19368675: length 21.8
  TOP w0.127: U1.F9 v1(178.81,122.61)
  L03_SIG1 w0.102: v1(178.81,122.61) 179.06,122.61 179.48,123.03 180.26,123.03 180.75,123.51 180.75,124.32 181.03,124.6 184.91,124.6 185.17,124.86 188.42,124.86 189.1,125.54
  L03_SIG1 w0.127: v2(195.58,129.81) 194.03,129.81 190.22,126 189.56,126 189.1,125.54
  BOTTOM w0.127: R412.2 v2(195.58,129.81)
N19368677: length 10.4
  TOP w0.102: 184.53,125.11 184.81,125.39 187.78,125.39 188.65,126.25
  TOP w0.127: R410.2 190.85,127.01 190.75,126.92 190.75,126.89 190.26,126.39 188.79,126.39 188.65,126.25 ; U1.B7 182.81,124.21 183.63,124.21 184.53,125.11
N19368786: length 15.6
  TOP w0.127: U1.D6 v1(180.41,125.01)
  BOTTOM w0.102: v1(180.41,125.01) 180.41,125.28 181.59,126.46 181.59,126.9 182.7,128.01 183.31,128.01 184.91,129.61 184.91,129.71 185.14,129.94 185.45,129.94 185.67,129.71 185.67,129.69 185.86,129.5 189.1,129.5
  BOTTOM w0.127: 189.1,129.5 189.89,129.5 190.5,130.11 190.5,130.7 191.39,131.59 R405.2
N19368850: length 11.4
  TOP w0.127: R398.2 191.2,131.23 191.05,131.23 188.91,129.1 188.87,129.06 187.29,129.06 187.27,129.07 187.07,129.07 186.56,128.56 186.54,128.56 186.21,128.23 185.09,128.23 183.47,126.61 182.81,126.61 U1.B4
N19368882: length 15.8
  TOP w0.127: U1.E7 v1(179.61,123.41)
  L03_SIG1 w0.102: v1(179.61,123.41) 180.04,123.41 180.39,123.76 180.39,124.36 180.81,124.78 180.81,125.16 181.06,125.41 181.66,125.41
  L03_SIG1 w0.127: 181.66,125.41 182.54,125.41 186.46,129.33 189.71,129.33 v2(190.5,128.54)
  BOTTOM w0.127: R402.2 v2(190.5,128.54)
N19368922: length 12.4
  TOP w0.127: U1.C5 v1(182.01,125.81)
  BOTTOM w0.102: v1(182.01,125.81) 182.25,126.05 182.25,126.98 182.81,127.55 183.85,127.55 185.22,128.92 188.98,128.92
  BOTTOM w0.127: R408.2 191.31,130.06 190.17,128.92 188.98,128.92
N19368946: length 9.9
  TOP w0.127: R394.2 191.48,130.14 190.42,130.14 189.15,128.87 189,128.87 188.96,128.83 187.17,128.83 186.67,128.34 186.64,128.34 186.26,127.95 185.24,127.95 184.37,127.08 184.36,127.08 183.5,126.21 U1.A4
N19368978: length 14.8
  TOP w0.127: U1.C4 v1(181.21,126.61)
  BOTTOM w0.102: v1(181.21,126.61) 181.21,126.87 182.67,128.33 183.17,128.33 184.36,129.51
  BOTTOM w0.127: 184.36,129.51 185.01,130.16 185.62,130.16 185.98,129.81 189.59,129.81 190.22,130.44 190.22,130.76 190.22,130.76 190.22,130.88 190.78,131.43 190.78,132.05 190.78,132.06 190.78,132.39 R404.2
N19369157: length 17
  TOP w0.102: 185.55,129.05 184.44,129.05 U1.A2
  TOP w0.127: R423.2 196.48,134.38 195.88,133.78 190.98,133.78 190.77,133.57 190.77,132.67 190.38,132.28 190.37,132.25 190.37,132.07 190.37,131.65 190.29,131.53 188.86,130.1 188.86,130.1 188.71,129.94 186.44,129.94 185.55,129.05
N19369167: length 19.9
  TOP w0.127: U1.E4 v1(179.61,126.61)
  L08_SIG2 w0.102: 180.06,125.92 179.61,126.37 v1(179.61,126.61) ; 189.1,129.48 188.49,129.48 187.93,128.92
  L08_SIG2 w0.127: 189.1,129.48 194.26,129.48 v2(195.45,128.28) ; 180.06,125.92 181.56,125.92 184.56,128.92 187.93,128.92
  BOTTOM w0.127: R433.2 v2(195.45,128.28)
N19369177: length 20
  TOP w0.127: R415.2 195.96,136.03 195.68,136.32 186.7,136.32 186.56,136.18 185.72,136.18 183.32,133.78 183.32,130.25 182.41,129.34 U1.B1
N19369187: length 16.2
  TOP w0.127: R396.2 195.83,132.86 195.58,132.6 193.61,132.6 193.44,132.44 193.22,132.44 193.05,132.27 191.07,132.27 190.85,132.04 190.85,131.4 190.71,131.26 190.71,131.26 188.82,129.38 186.84,129.38 185.98,128.51 184.91,128.51 183.41,127.01 U1.A3
N19369197: length 22.2
  TOP w0.127: U1.E5 v1(179.61,125.01)
  BOTTOM w0.102: v1(179.61,125.01) 179.83,125.01 180.21,124.63 180.68,124.63 180.82,124.78 180.82,125.34 181.81,126.33 181.81,126.83 182.73,127.75 183.69,127.75 185.12,129.17 189.1,129.17
  BOTTOM w0.127: 189.1,129.17 189.99,129.17 190.78,129.96 190.78,130.53 191.05,130.8 193.69,130.8 193.82,130.93 194.19,130.93 194.8,131.54 195.53,131.54 196.58,132.59 R420.2
N19369349: length 15.2
  TOP w0.127: v2(189.92,135.63) 190.91,134.63 R401.2 ; U1.B2 182.8,128.21 182.8,129.4 183.85,130.44 v2(183.85,130.75)
  L03_SIG1 w0.102: 185.34,134.89 184.71,134.25 184.71,131.61 v2(183.85,130.75)
  L03_SIG1 w0.127: v2(189.92,135.63) 186.08,135.63 185.34,134.89
N19369390: length 12.1
  TOP w0.127: U1.B3 182.81,127.41 183.3,127.41 183.31,127.42 183.37,127.42 183.6,127.65 183.6,127.71 184.66,128.77 185.72,128.77 186.65,129.69 188.8,129.69 188.86,129.75 188.86,129.76 190.61,131.51 190.61,131.51 190.61,132.17 R413.2
N19369435: length 26.7
  TOP w0.127: U1.E6 v1(179.61,124.21) ; R407.2 v2(195.48,137.66)
  L03_SIG1 w0.102: v1(179.61,124.21) U1.E6 180.01,125.27 180.77,126.02 181.38,126.02 182.67,127.31 182.67,131.07 184.51,132.91 184.51,134.59 184.8,134.89
  L03_SIG1 w0.127: v2(195.48,137.66) 194.18,136.36 186.28,136.36 184.8,134.89
N19369467: length 12.4
  TOP w0.127: U1.D5 v1(181.21,125.01)
  L08_SIG2 w0.127: v2(190.12,127.01) 189.46,127.01 188.54,127.93 184.84,127.93 182.32,125.41 181.61,125.41 v1(181.21,125.01)
  BOTTOM w0.127: R417.2 v2(190.12,127.01)
N19369503: length 17.7
  TOP w0.127: U1.D4 v1(180.41,126.61)
  BOTTOM w0.102: v1(180.41,126.61) 180.8,127 180.8,127.67 180.94,127.81 181.42,127.81 182.4,128.79 182.93,128.79 184.82,130.69 185.94,130.69 186.23,130.39 188.91,130.39 189.1,130.59
  BOTTOM w0.127: R409.2 191.4,135.7 190.7,135.01 190.7,133.98 190.47,133.75 190.47,132.87 190.22,132.62 190.22,132.29 190.22,132.28 190.22,131.7 189.1,130.59
N19369544: length 15.2
  TOP w0.127: U1.C3 v1(181.21,127.41)
  BOTTOM w0.102: 189.1,130.19 186.05,130.19 185.84,130.39 184.84,130.39 183.01,128.56 182.52,128.56
  BOTTOM w0.127: 182.52,128.56 181.37,127.41 v1(181.21,127.41) ; 189.1,130.19 189.51,130.19 189.94,130.62 189.94,130.88 189.94,130.88 189.94,131.03 190.5,131.58 190.5,132.17 190.5,132.17 190.5,132.51 190.78,132.78 190.78,133.58 190.78,133.58 190.78,133.66 R411.2
N19442104: length 18.8
  TOP w0.127: U1.H23 v1(177.21,110.61) ; v2(188.09,101.7) 188.09,101.49 188.33,101.25 R464.2
  L08_SIG2 w0.102: 184.4,104.07 184.4,104.61 184.61,104.82 184.61,106.78 183.55,107.83 183.55,107.95 182.91,108.6 180.73,108.6 179.54,109.79 177.93,109.79 177.21,110.51 v1(177.21,110.61)
  L08_SIG2 w0.127: v2(188.09,101.7) 185.71,101.7 184.52,102.89 184.5,102.89 184.4,102.99 184.4,104.07
N19442180: length 2.6
  TOP w0.127: U72.16 202.92,80.81 202.58,81.15 R877.1
N19508261: length 26.3
  TOP w0.102: v2(17.3,158.81) 16.96,159.16 16.05,159.16 15.95,159.06 15.95,158.78 15.85,158.67 R580.1 14.86,159.16 14.14,159.16 13.12,158.13 10.89,158.13 9.94,159.08 9.54,159.08 P3.7 ; U98.7 v2(26.12,160.34) 26.12,161.1 25.9,161.32 24.32,161.32 24.22,161.22 U104.1
  BOTTOM w0.102: v2(17.3,158.81) 17.64,159.16 21.49,159.16 23.77,161.44 25.9,161.44 26.12,161.23 v2(26.12,160.34)
N19508263: length 26.3
  TOP w0.102: U104.2 24.22,161.9 24.47,161.65 25.59,161.65 26.12,162.18 v2(26.12,162.88) U98.6 ; P3.2 10.49,159.76 10.26,159.53 10.26,159.22 11.02,158.46 12.98,158.46 14.01,159.49 14.86,159.49 R580.2 15.85,159.97 15.95,159.87 15.95,159.59 16.05,159.49 16.96,159.49 v2(17.3,159.83)
  BOTTOM w0.102: v2(17.3,159.83) 17.64,159.49 21.35,159.49 23.63,161.77 25.88,161.77 26.12,162.02 v2(26.12,162.88)
N19508331: length 2.4
  TOP w0.102: R540.2 U98.2
N19508333: length 215.4
  TOP w0.102: C317.1 39.37,164.49 v2(39.37,162.83) ; J25.1 44.25,162.83 v2(39.37,162.83) ; v2(39.37,162.83) 39.32,162.88 U98.3
  L03_SIG1 w0.102: v2(153.57,99.89) 154.3,99.15 154.3,94.17 153.52,93.39 153.52,88.46 148.39,83.33 133.53,83.33 129.06,87.81 113.46,87.81 113.46,87.8 112.48,87.8 112.48,87.81 110.18,87.81 109.85,88.13 59.62,88.13 45.48,102.27 44.05,102.27 38.41,107.91 38.41,133.93 38.42,133.94 38.42,139.89 46.13,147.59 46.13,160.62 45.09,161.66 40.54,161.66 v2(39.37,162.83)
  BOTTOM w0.102: R539.2 154,102.39 153.54,101.93 153.54,100.07 153.57,100.04 v2(153.57,99.89)
N19510567: length 25.2
  TOP w0.102: P2.7 9.48,201.81 9.93,201.81 10.79,200.95 13.29,200.95 14.04,201.7 14.28,201.7 14.38,201.6 14.38,201.32 14.48,201.22 R581.1 15.49,201.22 15.59,201.32 15.59,201.6 15.69,201.7 16.42,201.7 v2(16.73,201.4) ; U105.1 19.16,196.67 19.26,196.78 21,196.78 21.19,196.59 v2(21.19,195.8) U100.7
  BOTTOM w0.102: v2(16.73,201.4) 17.04,201.7 17.3,201.7 17.5,201.5 17.5,197.39 17.99,196.9 21.09,196.9 21.19,196.8 v2(21.19,195.8)
N19510569: length 25.2
  TOP w0.102: v2(16.73,202.34) 16.42,202.03 15.69,202.03 15.59,202.14 15.59,202.42 15.49,202.52 R581.2 14.48,202.52 14.38,202.42 14.38,202.14 14.28,202.03 13.91,202.03 13.16,201.28 10.92,201.28 10.44,201.77 10.44,202.35 10.64,202.55 P2.2 ; U105.2 19.16,197.32 19.38,197.11 20.88,197.11 21.19,197.42 v2(21.19,198.34) U100.6
  BOTTOM w0.102: v2(21.19,198.34) 21.19,197.33 21.09,197.23 18.12,197.23 17.83,197.53 17.83,201.64 17.44,202.03 17.04,202.03 v2(16.73,202.34)
N19510637: length 2.3
  TOP w0.127: U100.2 R545.2
N19510639: length 213.8
  TOP w0.127: v2(34.39,198.34) 34.39,199.85 C321.1 ; v2(34.39,198.34) U100.3 ; v2(34.39,198.34) J26.1
  L03_SIG1 w0.127: v2(113.64,97.83) 112.98,97.17 85.47,97.17 83.53,99.11 83.52,99.11 50.22,132.4 50.22,163.02 43.98,169.27 43.98,178.41 45.44,179.87 45.44,188.71 40,194.15 37.01,194.15 34.98,196.18 34.98,197.75 v2(34.39,198.34)
  L08_SIG2 w0.127: v2(161.42,99.05) 161.42,98.32 159.99,96.9 153.24,96.9 151.98,95.63 147.96,95.63 147.7,95.63 146.92,96.41 142.34,96.41 141.5,97.25 139.14,97.25 139.12,97.22 126.92,97.22 126.47,97.68 113.79,97.68 v2(113.64,97.83)
  BOTTOM w0.127: v2(161.42,99.05) 161.17,99.29 R544.2
N19520807: length 4.6
  TOP w0.102: v2(137.06,112.66) 137.06,113.45 136.86,113.65 136.86,114.7 U52.H8
  BOTTOM w0.102: v2(137.06,112.66) 137.06,112 137.03,111.98
  BOTTOM w0.127: R722.2 137.03,111.98
N19521112: length 2.7
  TOP w0.127: U52.A7 144.64,115.89 144.72,115.97 TP128.1
N19521127: length 6.3
  TOP w0.102: U52.E8 140.08,115.52 140.08,116.07 140.43,116.42 140.43,116.44 v1(140.72,116.73)
  BOTTOM w0.127: v1(140.72,116.73) 140.84,116.6 141.86,116.6 142.37,117.11 144.14,117.11 144.27,117.24 RA16.7
N19521129: length 6.2
  TOP w0.127: U52.D2 140.06,119.5 140.06,118.66 v1(141.1,117.62)
  BOTTOM w0.127: v1(141.1,117.62) 141.6,118.12 143.65,118.12 143.76,118.01 143.76,117.56
N19521147: length 7.7
  TOP w0.127: U52.E3 139.7,119.04 139.7,118.25 v1(140.46,117.49)
  BOTTOM w0.127: v1(140.46,117.49) 140.46,117.91 141.19,118.63 144.04,118.63 144.52,118.16 144.52,117.95 144.91,117.56 RA16.8
N19521183: length 4.4
  TOP w0.102: U52.E7 139.65,115.99 140.12,116.46 140.12,116.67 140.56,117.11 140.87,117.11 140.89,117.1 141.28,117.1 v1(141.32,117.05)
  BOTTOM w0.127: RA16.5 141.84,117.56 v1(141.32,117.05)
N19525941: length 3.8
  TOP w0.127: R216.2 R217.2 v2(150.76,182.83)
  BOTTOM w0.127: C428.1 v2(150.76,182.83)
N19533446: length 4.9
  TOP w0.127: v1(136.35,127.22) 136.96,127.22 137.19,127.45 137.19,128.84 136.83,129.2 136.83,129.91 136.98,130.06 136.98,130.06 U49.H8
  BOTTOM w0.127: R718.2 136.97,127.22 v1(136.35,127.22)
N19533734: length 3.2
  TOP w0.102: U49.A7 143.7,130.28
  TOP w0.127: 143.7,130.28 143.99,129.99 TP126.1
N19536013: length 46.2
  TOP w0.102: U1.W12 v1(168.41,119.41)
  TOP w0.127: v2(161.04,148.86) 161.47,149.29 R385.2
  L03_SIG1 w0.102: 171.03,134.39 171.58,133.85 171.58,129.71 172.03,129.26 172.03,127.25 172.26,127.01 172.59,127.01 172.8,126.81 172.8,125.5 172.01,124.71 172.01,121.38 171.25,120.61 169.1,120.61 168.41,119.93 v1(168.41,119.41)
  L03_SIG1 w0.127: v2(161.04,148.86) 162.05,149.87 169.4,149.87 171.77,147.51 171.77,143.82 171.22,143.27 171.22,140.27 170.81,139.87 170.81,134.58 171.01,134.39 171.03,134.39
N19536015: length 37.6
  TOP w0.127: R386.2 163.42,149.29 v2(163.5,149.37) ; U1.V9 v1(170.01,122.61)
  L03_SIG1 w0.102: 170.54,134.89 170.54,134.53 171.2,133.87 171.2,129.45 171.73,128.92 171.73,127.24 171.99,126.98 171.99,125.66 171.77,125.43 171.43,125.43 171.2,125.2 171.2,123.27 170.98,123.06 170.46,123.06 v1(170.01,122.61)
  L03_SIG1 w0.127: v2(163.5,149.37) 163.5,149.38 163.72,149.16 169.57,149.16 171.46,147.27 171.46,145.91 170.28,144.73 170.28,140.19 170.54,139.94 170.54,134.89
N19623002: length 9
  BOTTOM w0.127: R586.2 159.02,13.35 J31.14
N19626375: length 1.9
  TOP w0.127: R251.1 103.73,179.97 103.59,180.12 U26.6
N19628213: length 13.9
  TOP w0.102: U20.K1 68.83,196.23
  TOP w0.127: 68.83,196.23 68.71,196.23 68.3,195.82 66.88,195.82 65.96,194.91 58.62,194.91 TP73.1
N19628231: length 15.3
  TOP w0.102: 68.94,195.95 70.65,195.95 U20.K2
  TOP w0.127: TP72.1 57.66,192.32 59.73,194.39 65.9,194.39 67.06,195.54 68.53,195.54 68.94,195.95
N19631369: length 3.8
  TOP w0.127: R155.2 264.8,216.47 v2(264.68,216.36) 264.35,216.36 264.15,216.16 U18.7
  BOTTOM w0.127: R647.1 264.8,216.92 264.68,216.8 v2(264.68,216.36)
N19631412: length 4.4
  TOP w0.127: U18.11 260.35,213.76 v2(260.1,213.5) 260.34,213.26 U18.12
  BOTTOM w0.127: v2(260.1,213.5) 260.44,213.85 C405.2
N19631425: length 4.2
  TOP w0.127: C56.2 260.38,217.18 260.49,217.07 260.48,217.06 260.48,215.03 260.75,214.76 U18.9
N19631427: length 4.7
  TOP w0.127: R140.1 261.49,216.58 261.71,216.36 v2(262.25,216.36) 262.65,215.96 U18.8
  BOTTOM w0.127: R140.1 261.49,216.55 261.69,216.36 v2(262.25,216.36)
N19631452: length 2.7
  TOP w0.127: U18.13 261.67,212.43 261.54,212.3 v2(261.54,211.44)
  BOTTOM w0.127: v2(261.54,211.44) 261.04,211.95 C405.1
N19631454: length 1.5
  TOP w0.127: R140.2 C63.1
N19631468: length 2.1
  TOP w0.127: R157.2 264.15,210.99 U18.1
N19631560: length 2.9
  TOP w0.127: R131.2 256.55,225.68 255.91,226.33 J46.3
N19636064: length 9.6
  TOP w0.102: 242.11,165.29 v2(242.06,165.24)
  TOP w0.127: 242.11,165.29 242.11,166.89 243.87,168.65 U32.N2
  BOTTOM w0.127: v2(242.06,165.24) 241.55,165.24 240.79,164.48 R702.2 R888.1
N19636076: length 27.7
  TOP w0.152: v1(248.09,172.79) 247.77,173.12 U32.G8
  L03_SIG1 w0.127: v1(248.09,172.79) 248.35,172.79 250.33,170.8 264.44,170.8 266.57,168.67 268.4,168.67 268.86,169.13 268.86,170.12 268.76,170.22 268.76,171.31 TP109.1
  BOTTOM w0.127: C472.2 248.3,173.87 248.3,173 v1(248.09,172.79)
N19636197: length 16.8
  TOP w0.102: U32.J5 v1(245.49,172.14)
  BOTTOM w0.127: R668.2 239.14,181.88 240.56,180.46 240.56,178.04 242.57,176.04 244.09,176.04 245.06,175.07 245.06,173.04 245.49,172.61 v1(245.49,172.14)
N19636243: length 3.9
  TOP w0.127: U32.F8 248.11,173.77 248.15,173.73 249.89,173.73 250.5,173.11 250.5,173 250.99,172.51 R298.2
N19636273: length 4.2
  TOP w0.102: 248.18,174.09 247.44,174.09 U32.F7
  TOP w0.127: 248.18,174.09 248.24,174.03 R284.2
N19636291: length 9.4
  TOP w0.127: Y4.1 259.71,176.42 259.57,176.28 C127.2 258.05,176.28 255.8,174.03 R284.1
N19636350: length 9.4
  TOP w0.127: R298.1 253.34,172.51 254.13,173.29 256.13,173.29 257.24,174.4 C132.2 259.04,174.4 259.52,173.92 Y4.2
N19636388: length 22.7
  TOP w0.102: U32.M6 v1(246.14,170.19)
  L03_SIG1 w0.127: TP114.1 264.08,164.48 257.96,164.48 252.81,169.64 246.69,169.64 v1(246.14,170.19)
N19636390: length 21.1
  TOP w0.102: U32.M7 247.44,169.54 247.44,168.98
  TOP w0.127: 247.44,168.98 247.44,168.82 248.1,168.16 v2(248.1,167.93)
  L03_SIG1 w0.127: TP116.1 262.89,162.19 262.13,162.96 257.33,162.96 252.12,168.16 248.33,168.16 v2(248.1,167.93)
N19636467: length 15.5
  TOP w0.102: U32.M5 v1(245.49,170.19)
  TOP w0.127: R325.2 v2(257.06,163.99)
  L03_SIG1 w0.127: v2(257.06,163.99) 251.74,169.31 246.37,169.31 v1(245.49,170.19)
N19636469: length 14.1
  TOP w0.102: U32.M4 245.17,169.86 v1(245.49,169.54)
  TOP w0.127: R324.2 v2(255.16,163.99)
  L03_SIG1 w0.127: v1(245.49,169.54) 245.9,169.13 246.14,169.13 246.74,168.53 246.74,167.96 247.37,167.32 252.37,167.32 255.16,164.54 v2(255.16,163.99)
N19643422: length 22.6
  TOP w0.127: J18.2 271.4,131.82 273.54,133.96 R374.1
N19643490: length 24.5
  TOP w0.127: R370.1 v2(272.56,146.71)
  L08_SIG2 w0.127: v2(272.56,146.71) 273.94,145.33 J18.1
N19738237: length 12.1
  TOP w0.127: R266.1 50.34,181.6 v2(50.57,181.37) 54.41,181.37 54.91,180.86 54.91,179.29 55.19,179.01 55.19,178.63 54.74,178.17 U31.15
  BOTTOM w0.127: v2(50.57,181.37) 50.56,181.36 R677.2
N19748787: length 11.7
  TOP w0.127: TP69.1 v2(61.72,201.44) ; U20.C2 v1(71.35,199.73)
  L03_SIG1 w0.102: v1(71.35,199.73) 69.65,201.44 68.83,201.44
  L03_SIG1 w0.127: v2(61.72,201.44) 68.83,201.44
N19748789: length 12.1
  TOP w0.127: U20.C1 70.15,200.01 69.37,200.01 68.8,200.59 59.91,200.59 TP70.1
N19748805: length 10.9
  TOP w0.102: U20.D2 70.93,199.21 70.66,198.95 70,198.95 69.55,199.4 68.83,199.4
  TOP w0.127: 68.83,199.4 68.53,199.71 64.36,199.71 63.35,198.69 62.05,198.69 TP71.1
N19748807: length 7.9
  TOP w0.102: U20.D1 70.1,199.23
  TOP w0.127: 70.1,199.23 69.67,199.66 69.32,199.66 68.88,200.09 63.68,200.09 TP81.1
N19748859: length 13.2
  TOP w0.102: 71.17,201.56 71.2,201.54 71.23,201.54 71.63,201.14 71.63,201.1 71.63,201.1 71.63,200.62 71.93,200.32 U20.B4
  TOP w0.127: TP78.1 62.61,202.71 63.18,202.14 68.09,202.14 68.66,201.56 71.17,201.56
