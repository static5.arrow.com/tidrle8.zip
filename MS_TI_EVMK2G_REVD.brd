# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC3V3_EMMC: length 48.3
  TOP w0.203: v1(177.51,185.63) 177.51,185.38 U29.F5 ; U29.K9 175.01,186.25 ; 175.01,186.25 v1(175.02,186.24) ; 175.01,186.25 174.88,186.38 U29.J10 ; v1(176.39,184.99) 176.51,184.88 U29.E6
  TOP w0.381: v2(182.87,197.82) 182.87,196.42 183.13,196.17 R301.2 ; v2(182.87,197.82) 182.81,197.89 U34.1 v2(180.33,197.89) ; v2(182.87,197.82) 184.1,197.82 U36.5
  L03_SIG1 w0.381: v1(175.02,186.24) 175.61,186.24 175.65,186.2 176.23,186.2 176.25,186.22 176.91,186.22 v1(177.51,185.63)
  L08_SIG2 w0.381: v2(180.33,197.89) 180.33,197.31 180.34,197.31 180.34,195.21 176.02,190.9 170.31,190.9 168.91,189.5 168.91,187.85 169.42,187.34 169.42,187.21 170.39,186.24 173.35,186.24 173.35,186.32 173.74,186.7 174.37,186.7 174.45,186.63 174.63,186.63 v1(175.02,186.24)
  BOTTOM w0.381: C473.2 181.52,197.89 v2(180.33,197.89) 179.02,197.89 R694.1 ; C105.1 172.61,184.99 173.1,185.49 174.7,185.49 175.02,185.8 v1(175.02,186.24) ; v1(176.39,184.99) 176.87,184.99 v1(177.51,185.63) 177.64,185.5 C144.1 ; C483.2 v2(182.87,197.82)
VCC3V3_HDMI: length 330.3
  TOP w0.203: 294.57,51.96 U115.1 ; U115.23 292.12,52.83 292.21,52.74 U115.24 293.07,51.9 292.96,51.8 v2(292.96,50.87)
  TOP w0.254: U69.1 278.89,57.54 ; U115.23 v2(291.12,53.19)
  TOP w0.305: v2(92.79,19.55) 92.91,19.42 92.91,18.79 92.75,18.62 92.32,18.62 92,18.93 U108.24
  TOP w0.381: 277.62,58.31 v2(275.21,58.31) 275.6,57.92 R742.1 ; 277.62,58.31 278.79,59.47 v2(278.79,60.03) U84.5 ; 277.62,58.31 278.39,57.54 278.89,57.54 ; R561.1 v2(98.74,52.08) ; U69.16 286.26,57.54 286.26,57.55 286.26,58.18 v2(285.98,58.46) ; 112.65,31 115.34,33.7 115.34,39.41 112.85,41.9 112.85,47.52 v2(115.2,49.87) U91.5 ; 294.57,51.96 294.22,51.61 R813.1 v2(292.96,50.87)
  L03_SIG1 w0.381: v2(285.98,58.46) 286.44,58.92 286.44,59.58 285.98,60.03 v2(278.79,60.03) ; v2(112.65,29.1) 98.81,29.1 95.71,26 88.47,26 87.93,26.53 87.93,28.13 88.71,28.91 v2(88.71,29.6)
  L08_SIG2 w0.254: v2(275.21,58.31) 275.21,54.24 269.93,48.96 269.44,48.96 259.49,39 259.49,34.38 253.57,28.46 247.37,28.46 246.79,29.05 241.63,29.05 240.54,27.95 236.09,27.95 233.76,30.29
  L08_SIG2 w0.381: v2(115.2,49.87) 114.03,51.04 v2(112.22,51.04) ; 233.76,30.29 233.76,30.56 231.54,32.78 230.3,32.78 229.79,32.27 223.88,32.27 220.76,29.16 203.31,29.16 198.3,34.18 178.13,34.18 177.22,35.09 170.08,35.09 167.39,32.4 149.2,32.4 148.72,31.92 148.72,28.76 148.34,28.37 133.51,28.37 132.78,29.1 v2(112.65,29.1) ; v2(88.71,29.6) 87.63,28.52 87.63,24.7 v2(92.79,19.55) ; v2(291.12,53.19) 291.85,53.91 291.85,58.43 291.39,58.89 286.41,58.89 v2(285.98,58.46)
  BOTTOM w0.381: v2(98.74,52.08) 99.78,51.04 100.74,51.04 102.9,48.88 108.28,48.88 110.44,51.04 v2(112.22,51.04) ; C652.1 292.01,53.46 291.73,53.19 v2(291.12,53.19) ; v2(92.79,19.55) 92.64,19.41 C706.2 ; v2(292.96,50.87) 292.96,52.53 C733.2 ; v2(115.2,49.87) 114.5,50.57 C676.2 ; R772.1 v2(88.71,29.6) ; v2(278.79,60.03) C307.1 ; C651.1 v2(285.98,58.46)
VCC3V3_LCD: length 111.9
  TOP w0.203: 35.89,63.57 35.89,62.53 36.14,62.28 J22.4
  TOP w0.381: R455.1 v2(41.22,69.06) ; R429.1 v2(36.01,81.36) ; C256.1 34.28,64.73 31.19,64.73 29.57,63.11 29.57,57.09 31.14,55.51 60.2,55.51 61.48,56.8 v2(66.03,56.8) J21.1 ; C256.1 35.4,64.81 35.4,64.81 C257.1 36.13,63.81 35.89,63.57 ; C256.1 v2(34.36,63.81) ; FB32.2 77.71,53.64 v2(78.24,53.1) U58.5
  L03_SIG1 w0.381: v2(36.01,81.36) 38.69,81.36 39.47,80.58 39.47,72.99 41.22,71.24 v2(41.22,69.06) 41.22,67.4 40,66.18 36.3,66.18 34.36,64.24 v2(34.36,63.81)
  L08_SIG2 w0.508: v2(66.03,56.8) 66.03,54.13 68.33,51.83 76.97,51.83 v2(78.24,53.1)
  BOTTOM w0.381: C638.2 78.31,51.98 78.24,52.04 v2(78.24,53.1) ; v2(66.03,56.8) 66.03,55.57 C633.1 66.66,55.53 66.83,55.69 R729.1 ; R455.1 v2(41.22,69.06)
VCC3V3_MIPI: length 213.4
  TOP w0.254: v2(215.91,88.03) C780.2 216.63,89.17 216.64,89.18 U132.1
  TOP w0.381: R343.1 232.15,107.82 232.08,107.89 v2(232.08,107.96) ; R336.1 219.12,108.89 v2(218.69,108.47) ; v2(183.16,138.22) 183.16,137.89 183.49,137.56 R328.1 ; R326.1 215.14,84.71 216.17,84.71 ; v2(230.54,85.83) FB14.2 228.85,85.83 228.68,86.01 R317.2 ; 216.17,84.71 215.91,84.96 v2(215.91,88.03) ; 216.17,84.71 R865.2 ; v2(211.2,68.72) R391.2 R879.1
  L03_SIG1 w0.381: v2(230.54,85.83) 226.28,85.83 224.79,84.34 224.79,73.67 222.38,71.26 212.34,71.26 211.2,70.12 v2(211.2,68.72)
  L05_PWR1 w0.381: v2(183.16,138.22) 183.16,137.99 183.69,137.45 189.79,137.45 191.77,139.44 191.77,141.52 192.52,142.27 193.39,142.27 v2(193.4,142.28)
  L08_SIG2 w0.381: v2(206.65,96.43) 206.65,96.94 206.73,97.02 206.73,97.65 207.21,98.14 210.7,98.14 210.71,98.14 211.19,98.14 211.53,97.8 211.53,97.65 212.09,97.09 212.09,91 214.35,88.74 214.81,88.74 215.52,88.03 v2(215.91,88.03) ; v2(193.4,142.28) 204.44,142.28 224.96,121.77 224.96,113.97 222.07,111.09 222.07,109.11 221.72,108.75 218.97,108.75 v2(218.69,108.47) 219.43,107.74 219.43,102.55 219.27,102.39 219.27,98.5 219.99,97.78 219.99,95.87 v2(220.34,95.52)
  BOTTOM w0.381: R351.1 204.6,97.56 205.73,96.43 v2(206.65,96.43) 206.65,97.02 206.25,97.42 R355.1 ; v2(232.08,107.96) 229.74,105.63 224.33,105.63 221.49,108.47 v2(218.69,108.47) ; v2(230.54,85.83) 229.38,86.99 R904.1 229.74,87.38 229.74,88.53 228.47,89.8 222.63,89.8 222.5,89.93 222,89.93 221.87,89.8 221.74,89.8 220.47,88.53 218.69,88.53 218.19,88.03 v2(215.91,88.03) 216.94,89.05 216.94,90.62 218.41,92.09 222.25,92.09 222.76,92.6 222.76,94.25 221.49,95.52 v2(220.34,95.52)
VCC3V3_MLB: length 12.8
  TOP w0.203: v2(123.7,21.05) 123.88,20.87 124.08,20.87 124.77,20.18 J34.37 ; v2(123.72,20.21) 124.05,20.21 124.27,19.99 J34.39
  TOP w0.305: v2(125.22,11.57) 124.77,12.02 J34.38
  TOP w0.381: v2(119.41,14.82) 119.38,14.85 119.08,14.85 118.8,14.57 FB48.2 118.8,14.16 v2(119.51,14.16) ; v2(129.08,35.22) 129.11,35.19 R854.2
  BOTTOM w0.381: v2(125.22,11.57) 124.66,12.13 C709.1 ; C708.1 124.46,19.49 124.46,20.46 123.88,21.05 v2(123.7,21.05)
VCC3V3_NAND: length 38.4
  TOP w0.381: v2(119.25,129.16) 119.25,128.18 C668.1 ; C669.1 120.9,129.08 v2(120.25,129.73) ; R760.1 v2(115.82,110.63) ; v2(117.75,129.16) 117.75,128.15 C667.1
  L08_SIG2 w0.381: v2(117.75,129.16) 116.67,128.08 115.75,128.08 113.54,125.87 113.54,121.86 115.82,119.57 v2(115.82,110.63)
  BOTTOM w0.203: U87.37 v2(119.25,129.16) ; U87.39 v2(120.25,129.73) ; U87.12 v2(119.25,107.35) ; U87.34 v2(117.75,129.16)
  BOTTOM w0.381: R526.2 113.54,114.19 115.82,111.9 v2(115.82,110.63)
VCC3V3_PCIE: length 12.2
  TOP w0.381: R43.1 221.34,235.18 v2(221.34,233.97) ; 218.56,226.85 v2(218.57,226.84) ; R38.1 v2(222.88,237.38) ; v2(203.33,234.46) 203.34,234.44 FL19.2 207.17,233.36 207.52,233.02 J5.B8 ; R855.2 v2(220.84,247.66)
  BOTTOM w0.381: R594.2 216.03,240.44 216.03,241.02 216.07,241.02
  vias: v2(203.23,236.72) v2(203.2,235.98) v2(203.2,235.32) v2(218.06,230.65) v2(218.95,230.65) v2(221.74,239.41) v2(221.74,238.65) v2(222.12,234.33) v2(222.12,233.44) v2(222.12,232.55) v2(222.12,231.54) v2(222.12,230.77) v2(222.12,229.88) v2(222.12,229) v2(222.63,239.41) v2(222.63,238.65) v2(223.01,234.33) v2(223.01,233.44) v2(223.01,232.55) v2(223.01,231.54) v2(223.01,230.77) v2(223.01,229.88) v2(223.01,229) v2(223.27,239.03)
VCC3V3_QSPI: length 19.4
  TOP w0.305: U72.2 v2(192.11,79.01) ; U71.5 v1(188.92,78.61)
  TOP w0.381: U72.14 v2(204.43,77.74) ; R518.2 v2(202.95,69.61)
  BOTTOM w0.381: C657.2 188.92,77.18 v1(188.92,78.61) ; v2(192.11,79.01) 193.66,79.01 R743.1 194.8,78.99 194.94,79.14 C655.1 C659.2 ; R746.1 201.92,70.07 202.37,69.61 v2(202.95,69.61) ; C656.1 v2(204.43,77.74) ; R745.1 197.09,74.07 197.1,74.06
VCC3V3_R: length 6.1
  TOP w0.254: J19.1 225.18,82.07 225.42,82.31
  TOP w0.381: R317.1 227.84,83.45 226.69,82.31 225.42,82.31
VCC3V3_SD: length 53.1
  TOP w0.203: U107.1 232.75,26.75
  TOP w0.381: J37.4 239.19,25.37 C359.1 241.71,26.19 C356.1 242.53,26.09 243.2,25.41 v2(243.2,24.7) 244.35,25.85 244.35,27.45 242.82,28.97 239.78,28.97 239.27,29.48 238.76,29.48 238.28,29 R242.2 ; 232.75,26.75 232.48,27.03 R577.2 231.7,27.92 231.83,28.05 v2(234.22,28.05) 234.22,28.94 232.43,30.73 FB49.2
  BOTTOM w0.203: U111.10 239.06,32.22
  BOTTOM w0.381: v2(243.2,24.7) 243.84,25.34 243.84,28.08 243.27,28.65 R779.2 R777.2 243.27,32.46 242.87,32.86 239.7,32.86 239.06,32.22 238.51,32.78 234.42,32.78 234.22,32.59 R776.2 R778.2 R780.2 v2(234.22,28.05)
VCC3V3_SER_EXP: length 5.4
  TOP w0.381: 294.94,239.82 294.94,240.51 295.24,240.81 C81.1
  BOTTOM w0.381: J12.2 302.49,238.19 301.77,238.91 C82.1
VCC3V3_WLAN: length 105.5
  TOP w0.381: U125.1 181.46,215.25 180.96,215.75 179.21,215.75 ; v2(168,219.37) 167.94,219.32 167.94,219.02 167.7,218.77 R830.2 ; U126.1 168.76,212.06 168.5,211.8 C84.1 v2(167.29,211.03) 167.29,214.31 R838.2 ; v2(193.05,215.22) U128.1 193.05,211.56 193.04,211.55 C763.2 193.08,210.73 193.62,210.73 193.79,210.57 193.79,209.78 194.1,209.47 R843.2 ; 179.21,215.75 179.73,216.27 R842.2 ; 179.21,215.75 v2(178.98,215.75) 178.16,216.58 FB7.2 ; U144.5 C815.1 v2(161.12,220.23)
  L03_SIG1 w0.381: v2(161.12,220.23) 161.99,219.37 v2(168,219.37) 168,218.68 167.29,217.98 v2(167.29,211.03) 169.1,211.03 171.88,213.81 177.04,213.81 v2(178.98,215.75) 177.55,217.19 177.55,218.71 177.93,219.09 179.45,219.09 179.96,218.58 179.96,217.31 180.75,216.52 183.08,216.52 184.39,215.22 v2(193.05,215.22) 195.04,215.22 196.19,216.37 196.19,217.77 196.6,218.18 196.6,218.2 199.09,220.69 199.09,231.36 v2(200.15,232.42)
  BOTTOM w0.381: R609.1 v2(200.15,232.42) ; v2(178.98,215.75) 180.87,213.86 C83.1
VCC3V3_XDS: length 152.5
  TOP w0.203: U9.J9 v2(242.84,69.24) ; U9.D3 v2(237.24,74.04) ; U9.A9 v2(242.84,76.44) ; U9.B3 v2(237.24,75.64) ; U9.E7 v2(241.24,73.24) ; U9.C7 v2(241.24,74.84) ; U9.A7 v2(241.24,76.44)
  TOP w0.254: U41.1 227.51,100.61 227.52,100.62 C165.2 228.23,101.37 v2(228.47,101.61) ; 283.43,96.38 U6.15
  TOP w0.381: 288.52,96.14 288.26,96.39 v2(288.26,97.14) ; 288.52,96.14 C10.1 288.77,96.14 ; 288.52,96.14 287.6,96.14 286.85,96.89 285.34,96.89 284.95,96.49 C12.2 ; 288.77,96.14 289.78,96.14 291.29,94.63 TP198.1 291.34,94.58 293.37,94.58 293.85,95.06 293.85,101.34 294.11,101.59 U2.5 ; 288.77,96.14 289.03,96.39 v2(289.03,97.14) ; R169.2 v2(225.18,45.28) ; U12.7 246.42,87.37 C46.2 v2(245.51,87.28) ; R85.1 v2(270.41,63.57) ; R85.1 R105.1 ; R85.1 269.23,64.06 268.96,64.33 268.27,64.33 267.93,64.67 C30.2 266.7,65.34 v2(265.93,64.58) U11.8 ; R119.2 v2(264.9,58.23) ; R105.1 R111.1 270.23,60.52 v2(270.61,60.9) ; R105.1 v2(270.36,62.04) ; v2(248.46,106.39) 248.46,106.97 247.97,107.47 R113.2 ; R353.2 227.01,103.92 v2(226.65,103.56) ; R194.2 v2(232.38,38.2) ; 283.43,96.38 284.57,96.38 C12.2 ; R72.2 v2(259.46,95.39) ; v2(225.93,39.38) 226.2,39.65 R270.1 v2(225.15,40.32) ; R32.2 v2(255.52,23.89) ; U12.35 v2(237.49,99.99) 236.26,99.99 C62.2 ; R158.2 256.56,46.77 v2(256.67,46.88) ; R102.2 v2(253.47,63.31) ; R185.2 v2(246.1,41.85) ; C12.2 v2(284.95,95.24) ; v2(253.34,64.58) 253.59,64.84 R101.1 ; R33.2 v2(251.46,24.02) ; R172.2 v2(225.18,43.5) ; R143.2 v2(225.18,49.98) ; R123.2 v2(264.9,56.71) ; R178.2 v2(225.18,41.98) ; v2(248.74,87.98) 248.72,87.95 R46.2 ; R650.1 v2(261.59,44.52) ; R187.2 v2(230.86,38.37) ; 259.59,22.46 v2(259.59,23.76)
  L06_PWR2 w0.508: TP198.1 291.29,95.53 ; TP198.1 291.29,93.53 ; TP198.1 292.29,94.53 ; TP198.1 290.28,94.53 ; J4.1 254.53,83.64 ; J4.1 253.48,82.59 ; J4.1 255.59,82.59 ; J4.1 254.53,81.54
  BOTTOM w0.381: C383.1 243.94,70.14 243.2,69.41 243.01,69.41 v2(242.84,69.24) ; v2(241.24,73.24) 240.46,72.46 C382.1 ; R636.2 252.97,54.08 252.87,54.18 252.87,55.36 253.2,55.69 253.65,55.69 253.81,55.54 v2(254.23,55.54) ; R614.2 249.02,64.33 248.89,64.2 v2(248.89,64.07) ; v2(251.64,64.89) 251.64,65.04 251.22,65.46 R613.2 ; C380.1 240.88,74.84 v2(241.24,74.84) ; 264.39,51.45 263.9,51.95 263.9,55.71 v2(264.9,56.71) ; 264.39,51.45 265.55,51.45 265.89,51.12 v2(265.89,50.1) ; 264.39,51.45 264.05,51.45 263.9,51.3 R640.2 ; v2(223.91,48.58) 224.67,47.82 225.41,47.82 226.17,48.58 R649.2 ; v2(237.24,74.04) 236.51,74.04 236.07,73.6 C381.1 ; C375.1 240.65,77.03 v2(241.24,76.44) ; R641.2 270.67,72.97 271.68,73.98 271.68,75.76 v2(272.36,76.44) ; v2(235.69,66.99) R622.1 R621.1 R623.1 R624.1 v2(231.11,67.12) ; v2(223.91,46.93) 224.67,46.17 225.41,46.17 226.17,46.93 R644.2 ; R603.2 v2(287.25,91.94) ; v2(226.65,103.56) 226.06,104.15 220.47,104.15 220.2,103.89 R905.1 ; R612.2 256.05,95.88 256.29,95.65 257.05,95.65 257.2,95.8 259.06,95.8 v2(259.46,95.39) ; R617.2 244.45,65.22 v2(244.96,64.71) ; C46.2 v2(245.51,87.28) ; v2(271.04,80.99) 271.04,80.1 271.74,79.4 R142.2 ; v2(247.95,64.66) 247.5,65.12 R615.2 ; C379.1 238.59,75.64 v2(237.24,75.64) ; v2(242.84,76.44) 243.27,76.01 C378.1
  vias: v2(225.17,39.51)
VCC3V3_XDS_DVDD33: length 70.4
  TOP w0.102: v1(236.62,54.05) v1(236.62,53.25) v1(236.62,52.45) ; v1(237.42,47.65) v1(236.62,47.65) v1(236.62,46.85) ; v1(241.42,54.85) v1(242.22,54.85) v1(243.02,54.85) v1(243.82,54.85) v1(244.62,55.65) ; v1(243.82,50.05) v1(243.82,49.25) v1(243.82,48.45) ; v1(239.02,54.85) v1(238.22,54.85) v1(237.42,54.85) v1(236.62,54.85) ; v1(245.42,54.85) v1(245.42,54.05) v1(244.62,54.05)
  TOP w0.127: U17.J14 v1(244.62,52.45)
  TOP w0.254: U17.H5 v1(236.62,53.25) ; U17.F7 v1(238.22,54.85) ; U17.P12 v1(243.02,47.65) ; U17.P6 v1(237.42,47.65) ; U17.G9 v1(239.82,54.05) ; U17.F5 v1(236.62,54.85) ; U17.P5 v1(236.62,47.65) ; U17.F11 v1(242.22,54.85) ; U17.G14 v1(244.62,54.05) ; U17.N13 v1(243.82,48.45) ; U17.M13 v1(243.82,49.25) ; U17.F10 v1(241.42,54.85) ; U17.L4 v1(235.82,50.05) ; U17.R4 v1(236.62,46.85) ; U17.F12 v1(243.02,54.85) ; U17.L13 v1(243.82,50.05) ; U17.F6 v1(237.42,54.85) ; U17.G15 v1(245.42,54.05) ; U17.K13 v1(243.82,51.65) ; U17.E14 v1(244.62,55.65) ; U17.F15 v1(245.42,54.85) ; U17.K15 v1(245.42,51.65) ; U17.G5 v1(236.62,54.05) ; U17.F13 v1(243.82,54.85) ; U17.F8 v1(239.02,54.85) ; U17.J5 v1(236.62,52.45)
  TOP w0.381: FL3.1 v2(254.76,46.34) ; C86.2 v2(241.4,41.72) ; C87.2 v2(235.83,40.85)
  L03_SIG1 w0.102: v1(237.42,47.65) 237.79,48.02 237.79,48.28 237.8,48.29 237.8,48.6 237.79,48.61 237.79,49.08 237.8,49.09 237.8,49.4 237.79,49.41 237.79,49.49 237.64,49.65 236.22,49.65 v1(235.82,50.05)
  L03_SIG1 w0.254: v1(236.62,52.45) 235.82,51.65 v1(235.82,50.05)
  L03_SIG1 w0.381: v1(245.42,51.65) v1(244.62,52.45) v1(243.82,51.65)
  L08_SIG2 w0.102: 247.6,57.16 245.69,55.26 245.01,55.26 v1(244.62,55.65) ; v1(244.62,54.05) 244.22,53.65 244.22,52.85 v1(244.62,52.45)
  L08_SIG2 w0.381: v2(249.91,61.32) 250.77,60.46 250.77,58.61 249.33,57.16 247.6,57.16
  BOTTOM w0.381: C424.2 C409.2 235.88,46.85 v1(236.62,46.85) ; C411.2 235.63,52.45 v1(236.62,52.45) ; v1(243.82,50.05) 243.82,50.49 243.45,50.86 C393.2 243.45,51.27 v1(243.82,51.65) ; C47.2 248.03,56.93 248.03,56.02 247.81,55.8 C390.2 246.38,55.8 v1(245.42,54.85) v1(244.62,55.65) ; C67.2 243.02,47.03 v1(243.02,47.65) v1(243.82,48.45) ; C86.2 v2(241.4,41.72) ; C71.2 235.58,54.05 v1(236.62,54.05) v1(236.62,54.85) 235.9,55.56 C45.2 ; C43.1 v2(249.91,61.32)
  vias: v2(227.46,39.26) v2(228.47,39.26) v2(229.11,40.91) v2(229.11,39.89)
VCC5V0_DCDC: length 565.8
  TOP w0.102: 246.13,178.07 246.13,176.71 U32.B6
  TOP w0.203: U32.N3 244.51,169.21 244.51,167.65 244.22,167.36 ; v2(242.06,170.48) 242.1,170.52 U32.L1 ; U32.L7 U32.L8 249.23,169.05
  TOP w0.254: C150.2 243.97,167.11 244.22,167.36 ; 283.69,94.99 283.3,95.38 U6.13 ; 246.25,179.21 245.82,178.77 U32.A5 ; U6.6 278.89,96.38 ; U50.4 191.29,92.65
  TOP w0.305: v2(212.4,53.81) 212.31,53.72 C622.1
  TOP w0.381: v2(190.63,93.49) 190.63,92.84 190.44,92.65 ; R334.1 280.16,174.77 278.64,176.29 266.95,176.29 265.94,177.31 J17.3 ; R568.1 v2(100.53,54.35) ; v2(284.95,93.21) C13.1 284.07,93.97 283.69,94.35 283.69,94.99 ; C156.1 242.82,163.08 v2(242.7,163.21) ; v2(282.63,97.53) 282.65,97.5 U6.16 ; C206.1 190.44,92.65 ; 190.44,92.65 191.29,92.65 ; v2(277.35,94.5) C11.1 277.85,95.75 278.48,96.38 278.89,96.38 ; U8.2 v2(191.67,231.73) ; R67.2 v2(279.6,99.45) ; U8.1 v2(191.27,232.38) ; R155.1 v2(264.8,220.36) ; R457.1 38.94,69.15 v2(39.19,68.9) ; v2(283.82,98.67) 284.57,98.67 284.82,98.41 284.82,98.16 284.57,97.91 v2(283.82,97.91)
  TOP w0.508: 248.03,178.83 249.06,178.83 250.2,179.97 C112.2 ; 250.08,223.41 TP42.1 ; TP42.1 251.08,222.4 ; TP42.1 252.08,223.41 ; TP42.1 251.08,224.41
  TOP w0.61: U54.3 v2(212.4,52.54) ; U57.2 v2(191.8,26.74) ; U54.2 v2(212.4,53.81) ; U57.3 v2(191.8,25.47)
  TOP w1.016: L3.2 v2(247.78,209.44)
  L03_SIG1 w0.381: v2(190.47,65.93) 189.61,66.79 169.54,66.79 168.48,65.72 168.45,65.72 168.07,65.34 168.07,65.32 167.87,65.12 167.87,60.26 166.7,59.1 165.81,59.1 164.54,57.83 154.64,57.83 148.72,51.91 148.72,43.96 141.71,36.95 133.78,36.95 123.8,26.96 117.5,26.96 112.27,21.73 105.79,21.73 103,24.53 85.85,24.53 82.55,27.83 82.42,27.83 80.77,29.48 80.77,38.88 81.53,39.64 v2(81.53,55.01) ; v2(23.13,246.38) 24.43,245.07 122.86,245.07 127.3,240.63 145.19,240.63 152.35,247.79 175.39,247.79 183.21,239.97 183.21,239.46 187.47,235.2 187.69,235.2 188.04,234.86 188.04,234.63 188.72,233.95 189.23,233.95 v2(189.86,233.31) ; v2(91.57,55.01) 99.87,55.01 v2(100.53,54.35)
  L05_PWR1 w0.508: TP42.1 251.08,224.41 ; TP42.1 251.08,222.4 ; TP42.1 250.08,223.41 ; TP42.1 252.08,223.41 ; J17.3 267,178.45 ; J17.3 264.87,178.45 ; J17.3 265.94,179.52 ; J17.3 265.94,177.38
  L08_SIG2 w0.381: v2(39.19,68.9) 34.34,68.9 33.53,68.09 33.53,55.01 38.1,50.43 62.99,50.43 64.14,51.58 64.14,56.66 74.3,66.82 90.42,66.82 95,62.24 95,55.13 95.76,54.37 100.51,54.37 v2(100.53,54.35)
  BOTTOM w0.381: C471.2 254.25,173.04 v2(254.71,172.58) ; v2(81.53,55.01) v2(91.57,55.01) ; R611.2 275.8,94.21 276.1,94.5 v2(277.35,94.5) ; v2(251.08,185.31) 250.32,184.55 v2(248.79,184.55) ; C484.2 243.84,162.54 243.84,162.83 v2(243.46,163.21) ; R592.1 v2(23.13,246.38) ; v2(191.8,26.74) 192.32,26.21 C634.1
  BOTTOM w0.508: 253.6,172.47 253.59,172.47 254.28,171.78 254.28,170.73 253.82,170.27 R692.1
  vias: v2(190.63,233.31) v2(191.39,233.31) v2(192.15,233.31) v2(246.89,221.25) v2(246.89,219.98) v2(246.89,218.71) v2(246.89,217.44) v2(246.89,216.17) v2(246.89,214.9) v2(246.89,213.63) v2(246.89,212.36) v2(246.89,211.09) v2(246.89,209.82) v2(246.89,208.55) v2(246.89,207.28) v2(246.89,206.01) v2(248.16,221.25) v2(248.16,219.98) v2(248.16,218.71) v2(248.16,217.44) v2(248.16,216.17) v2(248.16,214.9) v2(248.16,213.63) v2(248.79,185.31) v2(249.43,221.25) v2(249.43,219.98) v2(249.43,218.71) v2(249.43,217.44) v2(249.43,216.17) v2(249.43,214.9) v2(249.43,213.63) v2(250.7,225.06) v2(250.7,221.25) v2(250.7,219.98) v2(250.7,218.71) v2(250.7,217.44) v2(250.7,216.17) v2(250.7,214.9) v2(250.7,213.63) v2(251.08,161.94) v2(251.33,183.78) v2(251.33,161.05) v2(251.97,225.06) v2(252.22,161.05) v2(253.24,223.79) v2(278.89,99.46) v2(283.08,93.99) v2(283.08,93.23) v2(283.21,97.8) v2(283.97,93.11)
VCC5V0_HDMI: length 46.8
  TOP w0.381: v2(85.51,27.29) 85.51,25.7 U108.11 ; U103.1 v2(102.76,53.52) 102.76,54.14 R568.2
  L03_SIG1 w0.381: v2(85.51,27.29) 85.51,47.45 88.21,50.15 101.3,50.15 101.96,50.81 101.96,52.71 v2(102.76,53.52)
  BOTTOM w0.381: v2(102.76,53.52) 103.07,53.2 C697.1 ; C704.2 v2(85.51,27.29)
VCC5V0_LCD: length 5.8
  TOP w0.279: C222.1 44.27,78.65 44.26,78.65 U53.2
  TOP w0.381: R457.2 v2(38.94,72.46) ; C222.1 45.1,79.48 45.57,79.01 v2(45.54,79.01) ; R456.1 v2(42.75,69.03)
VCC5V0_USB0_PM: length 94.3
  TOP w0.127: v1(184.48,114.61) 182.81,114.61 U1.B19
  TOP w0.381: v2(192.58,84.37) 201.74,84.37 201.87,84.5 205.23,84.5 206.04,83.68 206.04,82.13 206.25,81.93 206.25,66.31 217.47,55.08 U54.8 ; FB45.1 v2(218.31,33.31)
  TOP w0.61: U54.8 v2(220.83,55.08) ; U54.7 v2(220.83,53.81) ; U54.6 v2(220.83,52.54)
  BOTTOM w0.102: v1(184.48,114.61) 184.48,114.11 184.73,113.86 185.17,113.86 186.28,112.74 186.28,107.92 185.06,106.7 185.06,104.39 185.3,104.15 185.3,104.03
  BOTTOM w0.381: 185.3,104.03 185.3,103.39 186.34,102.35 188.41,102.35 189.19,101.56 189.19,101.56 189.51,101.23 189.82,101.23 191.45,99.6 191.45,95.46 192.15,94.76 192.91,94.76 193.42,94.25 193.42,93.11 192.61,92.29 192.61,84.39 v2(192.58,84.37)
  vias: v2(218.31,34.2) v2(218.34,32.6) v2(219.2,34.2) v2(219.2,33.31) v2(219.23,32.6) v2(221.74,54.75) v2(221.74,53.86) v2(221.74,52.59)
VCC5V0_USB1_PM: length 109.5
  TOP w0.102: 186.59,112.33 185.22,112.33 184.94,112.61 U1.A21
  TOP w0.254: FB47.1 v2(193.65,21.86)
  TOP w0.381: 186.59,112.33 186.92,112.33 187.73,111.52 187.73,111.05 189.29,109.49 v2(189.86,109.49) ; v2(200.22,25.47) v2(200.22,26.74) v2(200.22,28.01)
  TOP w0.61: U57.6 v2(200.22,25.47) ; U57.7 v2(200.22,26.74) ; U57.8 v2(200.22,28.01)
  L03_SIG1 w0.254: v2(189.86,109.49) 190.47,108.88 192.91,108.88 193.17,108.63 193.17,103.47 194.56,102.07 v2(194.56,98.92)
  L08_SIG2 w0.381: v2(194.56,98.92) 195.05,98.44 195.05,97.02 194.41,96.38 194.41,93.94 194.74,93.61 195.5,93.61 195.96,93.16 195.96,64.4 193.67,62.12 v2(192.02,62.12)
  BOTTOM w0.508: v2(200.22,28.01) 200.91,28.7 200.91,53.23 v2(192.02,62.12)
  vias: v2(192.76,22.75) v2(192.76,21.86) v2(193.65,22.75) v2(194.54,22.75) v2(194.54,21.86)
VCC5V_UART2: length 2.7
  TOP w0.127: R914.1 J49.3
VCC5V_VUSB_CP2105: length 25.6
  TOP w0.254: U74.7 18.69,58.34 18.78,58.25 19.06,58.25 19.19,58.38 U74.8 ; 13.46,62.99 v2(13.46,62.12)
  TOP w0.381: C286.1 v2(15.91,62.99) ; C286.1 14.99,62.99 U73.6 ; C286.1 13.46,62.99 13.45,63.01 11.01,63.01 C338.1 10.1,62.76 10.04,62.7 J23.1 ; v2(18.17,56.95) C305.1 18.87,57.6 19.06,57.79 19.06,58.25
  L03_SIG1 w0.381: v2(18.17,56.95) 18.17,57.78 v2(18.19,57.8)
  BOTTOM w0.381: v2(13.46,62.12) 17.27,62.12 18.17,61.22 v2(18.17,56.95)
VCC12V0_AUD_EXP: length 28.9
  TOP w0.381: C167.1 v2(295.66,151.4) ; FL6.2 v2(295.66,156.86) ; C166.1 v2(295.66,153.94)
  L03_SIG1 w0.508: 302.51,140.09 JP1.4 ; JP1.4 302.51,142.2 ; JP1.4 303.57,141.14 ; JP1.4 301.46,141.14 ; 301.46,143.68 JP1.2 ; JP1.2 302.51,144.74 ; JP1.2 302.51,142.63 ; JP1.2 303.57,143.68 ; JP1.6 302.51,139.66 ; JP1.6 301.46,138.6 ; JP1.6 302.51,137.55 ; JP1.6 303.57,138.6
  L08_SIG2 w0.508: 302.51,137.55 JP1.6 ; JP1.6 303.57,138.6 ; JP1.6 301.46,138.6 ; JP1.6 302.51,139.66 ; JP1.2 302.51,144.74 ; JP1.2 301.46,143.68 ; JP1.2 303.57,143.68 ; JP1.2 302.51,142.63 ; JP1.4 302.51,142.2 ; JP1.4 303.57,141.14 ; JP1.4 302.51,140.09 ; JP1.4 301.46,141.14
  vias: v2(294.77,158.38) v2(296.55,158.38) v2(296.55,156.86) v2(296.55,154.32) v2(296.55,152.29) v2(296.55,149.75) v2(300.36,146.45) v2(300.36,145.43) v2(302.39,146.45) v2(302.39,145.43)
VCC12V0_DC_IN: length 38.5
  TOP w0.203: U18.4 v2(266,213.76) ; U18.5 v2(266.57,214.26) ; U18.6 v2(266,214.76)
  TOP w0.381: 117.02,12.26 v2(117.02,11.29) ; 117.02,12.26 FL11.1 115.99,12.35 v2(115.98,12.33) ; 117.02,12.26 v2(116.2,11.44) ; FB51.1 v2(292.92,234.43) ; FL6.1 v2(292.67,158.07) ; v2(292.86,160.16) 293.07,160.37 TP64.1 ; v2(231.47,237.43) 232.05,236.84 232.88,236.84 R826.2
  TOP w0.508: 293.07,163.07 TP64.1 292.06,162.07 ; 268.11,219.34 TP63.1 ; TP63.1 270.12,219.34 ; TP63.1 269.11,220.35 ; TP63.1 269.11,218.34
  L06_PWR2 w0.762: 292.06,162.07 TP64.1 ; TP64.1 293.07,161.06 ; TP64.1 293.07,163.07 ; TP64.1 294.07,162.07 ; J50.1 293.62,230.19 ; J50.1 294.69,229.12 ; J50.1 292.56,229.12 ; J50.1 293.62,228.06 ; TP63.1 269.11,220.35 ; TP63.1 270.12,219.34 ; TP63.1 268.11,219.34 ; TP63.1 269.11,218.34
  BOTTOM w0.254: R892.1 v2(284.88,211.33)
  BOTTOM w0.381: C75.1 v2(266.83,216.3) ; C740.1 243.09,237.38 v2(241.3,237.38) ; R610.1 132.84,225.31 133.1,225.06 133.1,224.58 133.05,224.53 v2(133.05,223.96)
  vias: v2(132.59,213.12) v2(133.6,213.12) v2(134.52,213.12) v2(135.13,216.58) v2(135.13,215.66) v2(135.13,214.64) v2(135.89,213.37) v2(136.14,216.45) v2(136.14,215.53) v2(136.14,214.52) v2(231.01,189.37) v2(231.01,188.23) v2(232.16,189.37) v2(232.16,188.23) v2(233.17,188.23) v2(234.19,188.23) v2(235.2,188.23) v2(236.6,188.23) v2(237.62,188.23) v2(238.63,188.23) v2(241.05,233.69) v2(241.17,231.66) v2(241.17,230.65) v2(241.17,229.76) v2(241.17,229) v2(241.17,228.23) v2(241.17,227.47) v2(241.17,226.71) v2(241.94,226.71) v2(242.7,226.71) v2(250.7,249.7) v2(250.7,248.81) v2(251.97,249.7) v2(251.97,248.81) v2(253.24,249.7) v2(253.24,248.81) v2(254.63,249.7) v2(254.63,248.81) v2(256.16,249.7) v2(256.16,248.81) v2(257.43,249.7) v2(257.43,248.81) v2(266.95,217.18) v2(266.95,215.41) v2(267.21,213.63) v2(267.21,211.85) v2(267.21,210.83) v2(267.21,209.82) v2(281.69,209.56) v2(281.69,208.8) v2(281.69,208.04) v2(281.69,207.28) v2(282.45,209.56) v2(282.45,208.8) v2(282.45,208.04) v2(282.45,207.28) v2(283.21,209.56) v2(283.21,208.8) v2(283.21,208.04) v2(283.21,207.28) v2(283.84,209.56) v2(283.84,208.8) v2(283.84,208.04) v2(283.84,207.28) v2(284.61,209.56) v2(284.61,208.8) v2(284.61,208.04) v2(284.61,207.28) v2(285.37,209.56) v2(285.37,208.8) v2(285.37,208.04) v2(285.37,207.28) v2(286,211.85) v2(286,211.22) v2(286,210.58) v2(286.13,209.56) v2(286.13,208.8) v2(286.13,208.04) v2(286.13,207.28) v2(286.77,211.85) v2(286.77,211.22) v2(286.77,210.58) v2(287.78,211.85) v2(287.78,211.22) v2(287.78,210.58) v2(288.54,211.85) v2(288.54,211.22) v2(288.54,210.58) v2(291.85,234.46) v2(292.25,191.33) v2(292.23,160.16) v2(292.23,159.4) v2(292.23,158.76) v2(292.3,192.24) v2(292.48,234.96) v2(292.86,159.4) v2(292.86,158.76) v2(293.12,192.24) v2(293.17,191.4) v2(293.14,190.59) v2(293.95,192.22) v2(293.93,191.4) v2(293.9,190.62)
VCC12V0_MLB: length 14.9
  TOP w0.305: J34.40 v2(124.27,11.46)
  TOP w0.381: FL11.2 117.02,14.87 118.31,14.87 118.56,15.12 C358.1 ; C358.1 C357.1 ; C358.1 119.41,15.71 v2(119.43,15.74)
  BOTTOM w0.381: v2(124.27,11.46) 123.8,11.46 123.04,12.22 123.04,14.32 121.62,15.74 v2(119.43,15.74)
VCC12V0_PCIE: length 4.4
  TOP w0.381: J5.A3 v2(218.07,238.02) ; FL1.2 v2(248.16,247.66) ; J5.A2 v2(218.07,239.02)
  vias: v2(206.38,247.66) v2(206.38,246.65) v2(206.38,245.63) v2(206.38,244.62) v2(207.26,245.63) v2(207.26,244.62) v2(207.39,247.66) v2(207.39,246.65) v2(207.64,240.43) v2(207.64,239.28) v2(207.64,238.14) v2(208.15,245.63) v2(208.15,244.62) v2(208.28,247.66) v2(208.28,246.65) v2(212.72,248.17) v2(212.72,247.16) v2(213.74,248.17) v2(213.74,247.16) v2(214.63,248.17) v2(214.63,247.16) v2(216.28,248.17) v2(216.28,247.16) v2(217.3,248.17) v2(217.3,247.16) v2(218.19,248.17) v2(218.19,247.16) v2(218.55,238.54) v2(219.03,238.99) v2(219.03,237.99) v2(244.86,249.57) v2(244.86,248.68) v2(244.98,246.52) v2(244.98,245.63) v2(245.87,249.57) v2(245.87,248.68) v2(246,246.52) v2(246,245.63) v2(247.01,249.57) v2(247.01,248.68) v2(247.01,246.65) v2(247.01,245.51) v2(248.03,249.57) v2(248.03,248.68) v2(248.03,246.52) v2(248.03,245.51)
VCC12V0_SER_EXP: length 5.2
  TOP w0.381: v2(296.09,234.56) 294.91,234.56 FB51.2 294.78,235.07 295.08,235.36 C750.1
  BOTTOM w0.381: C749.1 295.73,233.67 296.09,234.02 v2(296.09,234.56)
VCC_BMC_LCD: length 36.5
  TOP w0.381: C34.2 C33.2 59.94,223.48 MOD1.12
  BOTTOM w0.381: MOD1.12 59.43,224.85 59.44,224.86 59.44,228.46 57,230.9 40.61,230.9 39.71,231.8 R100.1 37.97,233.34 38.37,233.74 R106.2 39.14,234.41 39.27,234.54 R112.2
VCC_DDR_VREF: length 270.6
  TOP w0.152: U49.J8 136.85,130.73 136.85,131.36 136.24,131.97 ; U39.J8 136.85,161.21 136.85,161.84 136.24,162.45 136.61,162.81 138.03,162.81 138.81,163.59 138.81,164.05 138.45,164.41 138.45,165.81 138.65,166.01 139.25,166.01 U39.E1 ; U49.E1 139.25,135.53 138.65,135.53 138.45,135.33 138.45,133.93 138.81,133.57 138.81,133.11 138.03,132.33 136.89,132.33 v2(136.52,131.97) ; U27.E1 139.25,181.25 138.65,181.25 138.45,181.05 138.45,179.65 138.81,179.29 138.81,178.83 138.03,178.05 136.61,178.05 136.24,177.69 136.85,177.08 136.85,176.45 U27.J8 ; U45.E1 139.25,150.77 138.65,150.77 138.45,150.57 138.45,149.17 138.81,148.81 138.81,148.35 138.03,147.57 136.61,147.57 136.24,147.21 136.85,146.6 136.85,145.97 U45.J8 ; U52.J8 136.85,115.49 136.85,116.12 136.24,116.73 136.61,117.09 138.03,117.09 138.81,117.87 138.81,118.33 138.45,118.69 138.45,120.09 138.65,120.29 139.25,120.29 U52.E1
  TOP w0.254: U49.E1 139.33,136.25 139.33,137.03 138.35,138 v2(138.35,139.49) ; U45.E1 139.62,151.17 139.32,151.48 139.32,152.39 138.05,153.66 138.05,153.67 v2(137.69,154.03) ; U27.E1 139.65,181.78 139.37,182.06 139.37,182.77 v2(140.11,183.5)
  TOP w0.381: v2(138.35,139.49) 136.78,141.06 128.65,141.06 ; 128.65,141.06 128.65,133.2 128.75,133.1 128.75,119.18 v2(129.43,118.51) 129.62,118.32 C610.2 ; 128.65,141.06 v2(128.65,147.21) ; v2(138.8,169.45) 136.98,171.26 132.21,171.26 128.65,167.71 v2(128.65,165.98) ; U25.4 v2(115.06,207.56)
  TOP w0.508: 136.24,177.69 135.81,177.69 135.15,178.35 131.41,178.35 131.36,178.4 129.55,178.4 v2(128.92,177.76) ; 128.75,132.53 129.9,132.53 130,132.63 135.15,132.63 135.81,131.97 v2(136.52,131.97) ; v2(128.65,147.21) 129.51,148.07 132.09,148.07 132.39,147.77 135.25,147.77 135.81,147.21 136.24,147.21 ; 136.24,116.73 135.81,116.73 135.15,117.39 132.88,117.39 132.74,117.53 C610.2 ; v2(128.65,162.7) 129.26,163.31 132.68,163.31 132.88,163.11 135.15,163.11 135.81,162.45 136.24,162.45
  L03_SIG1 w0.381: v2(128.65,147.21) v2(128.65,162.7) v2(128.65,165.98) 128.65,177.5 v2(128.92,177.76)
  BOTTOM w0.254: v2(140.11,183.5) 140.11,184.48 C455.2 ; v2(137.69,154.03) C510.2
  BOTTOM w0.381: v2(129.43,118.51) 129.46,118.47 129.46,117.68 C610.2 ; C521.2 129.78,147.21 v2(128.65,147.21) ; C440.2 128.4,178.29 v2(128.92,177.76) ; C487.2 v2(138.8,169.45) ; v2(115.06,207.56) 115.47,207.96 116.52,207.96 C103.2 116.57,207.26 116.12,206.81 C100.1 115.06,206.14 114.55,205.63 114.55,188.86 115.32,188.1 115.32,170.45 122.16,163.6 C500.2 128.42,162.93 v2(128.65,162.7) ; v2(136.52,131.97) 137.15,131.35 C554.2
  BOTTOM w0.508: C540.2 138.2,139.33 v2(138.35,139.49) 138.84,139.97 145.41,139.97 152.68,132.7 C561.2 152.82,130.32 153.78,130.32 R403.2
VCC_VBUS_XDS: length 125.4
  TOP w0.381: v2(294.64,103.77) 294.64,102.72 U2.6 ; v2(284.95,101.6) R47.1 R64.2 ; R76.1 v2(274.55,92.06) ; U4.5 v2(290.69,102.24)
  L03_SIG1 w0.381: v2(249.43,19.83) 249.43,20.67 260.1,31.33 260.1,39.64 269.27,48.81 269.27,57.52 275.59,63.85 275.59,73.8 273.81,75.58 273.81,80.28 274.55,81.02 v2(274.55,92.06)
  L08_SIG2 w0.381: v2(274.55,92.06) 281.86,92.06 282.83,91.1 285.14,91.1 286.08,92.04 286.08,100.47 v2(284.95,101.6) 285.58,102.24 v2(290.69,102.24) 293.11,102.24 v2(294.64,103.77)
  BOTTOM w0.381: C367.1 v2(290.69,102.24) ; v2(294.64,103.77) 294.46,103.6 294.46,102.9 C364.1
VDD2_PLL1: length 7.8
  TOP w0.203: U62.37 145.75,93.57 146.18,93.99
  TOP w0.254: v2(147.19,95.26) 147.19,93.95 146.15,92.9 U62.37
  TOP w0.381: C269.1 v2(147.87,94.93) ; FB31.1 v2(148.26,96.66)
  BOTTOM w0.381: C635.1 149.16,94.93 v2(147.87,94.93)
VDD2_PLL2: length 5.9
  TOP w0.381: FB26.1 v2(143.93,99.33) 143.64,99.04 143.64,96.15 143.93,95.86 C262.1
  vias: v2(144.53,94.76) v2(145.25,94.76)
VDD18_1V8: length 20.7
  TOP w0.152: U1.H5 v1(178.01,125.81)
  L03_SIG1 w0.102: 179.2,128.77 179.2,126.38 179.04,126.23 178.68,126.23 178.27,125.81 v1(178.01,125.81)
  L03_SIG1 w0.254: 181.58,134.89 179.74,133.05 179.74,129.64 179.2,129.1 179.2,128.77
  L03_SIG1 w0.381: 181.58,134.89 182.55,135.85 v2(182.55,137.23)
  BOTTOM w0.127: v1(178.01,125.81) 178.41,126.21 178.41,127.68 178.54,127.81 179.05,127.81 179.54,128.3 C527.1 C184.1 C175.1
  BOTTOM w0.381: FB19.2 182.07,137.71 v2(182.55,137.23)
VDDAHV: length 39.1
  TOP w0.127: U1.K7 v1(175.61,124.21)
  L06_PWR2 w0.127: 176.8,124.85 176.56,124.61 176,124.61 v1(175.61,124.21) 175.61,124.67 176.02,125.08 176.02,125.18 176.02,125.18 176.02,125.64 176.02,125.65 176.02,129.31 175.13,130.19 175.13,133.85 175.67,134.38 175.67,134.39 175.7,134.43 175.7,134.7 175.89,134.89 175.89,132.98 176.23,132.65 176.23,129.86 176.8,129.28 176.8,124.85
  L06_PWR2 w0.381: v2(176.91,142.76) 176.48,142.33 176.48,141.49 176.17,141.19 176.17,135.17 175.89,134.89
  BOTTOM w0.381: C572.1 175.72,124.11 v1(175.61,124.21) ; FB21.2 181.99,143.48 181.98,143.5 C204.1 178.38,143.5 178.29,143.59 C201.1 177.52,143.37 v2(176.91,142.76)
VDDI: length 6.3
  TOP w0.127: U29.C2 U29.C1 182.4,183.38 v2(182.49,183.47) C146.1
  BOTTOM w0.127: C492.1 v2(182.49,183.47)
VDDR_VTT: length 29.9
  TOP w0.381: C117.1 120.9,199.27 120.65,199.02 v2(120.65,198.01) ; C117.1 122.3,199.27 122.56,199.02 v2(122.56,198.01) ; C117.1 v2(121.67,198.01) ; v2(148.29,176.09) 148.29,175.52 148.6,175.2 R210.2 ; R222.1 117.09,211.34 v2(117.6,211.85) ; U25.8 v2(118.87,198.64) ; v2(147.7,183.66) 147.97,183.39 R208.2
  L08_SIG2 w0.508: v2(125.09,197.12) 125.09,204.36 v2(117.6,211.85)
  BOTTOM w0.381: C118.2 v2(118.87,198.64)
  vias: v2(121.67,187.09) v2(121.67,184.04) v2(121.67,182.39) v2(121.67,180.61) v2(121.67,179.08) v2(121.67,177.81) v2(121.67,176.42) v2(121.67,175.02) v2(121.67,173.37) v2(121.67,171.85) v2(121.79,188.61) v2(121.79,185.56) v2(123.06,196.23) v2(123.19,197.12) v2(123.7,199.28) v2(123.83,198.01) v2(123.95,196.23) v2(124.21,187.72) v2(124.33,197.12) v2(124.97,196.23)
VINPUT: length 12.6
  TOP w0.254: v2(275.3,210.96) 277.24,210.96 277.5,211.22 R922.1
  TOP w0.508: 291.08,228.06 J50.2 ; J50.2 291.08,230.19 ; J50.2 290.02,229.12
  BOTTOM w0.254: U149.2 275.81,212.62 C824.1
  BOTTOM w0.508: 290.02,229.12 J50.2 ; J50.2 291.08,228.06 ; J50.2 291.08,230.19
  vias: v2(284.99,224.93) v2(284.99,224.04) v2(285.88,224.93) v2(285.88,224.04) v2(286.77,224.93) v2(286.77,224.04) v2(287.65,224.93) v2(287.65,224.04) v2(288.54,224.93) v2(288.54,224.04) v2(289.43,224.93) v2(289.43,224.04) v2(290.32,227.6) v2(290.32,226.71) v2(290.32,225.82) v2(290.32,224.93) v2(290.32,224.04) v2(291.21,227.6) v2(291.21,226.71) v2(291.21,225.82) v2(291.21,224.93) v2(291.21,224.04)
VSS_RTC: length 22.7
  TOP w0.127: 248.64,52.47 247.8,52.47 U17.H18
  TOP w0.381: C52.2 v2(258.56,53.49) ; 248.64,52.47 248.97,52.47 250.29,53.79 250.29,55.69 251.33,56.73 255.45,56.73 v2(255.6,56.58) ; C53.2 v2(256.78,57.89)
  L03_SIG1 w0.381: v2(255.6,56.58) 256,56.98 256,57.11 v2(256.78,57.89)
  L08_SIG2 w0.381: v2(255.6,56.58) 256,56.18 256,56.05 v2(258.56,53.49)
  BOTTOM w0.381: R630.1 v2(255.6,56.58)
1P8V_EN: length 133.1
  TOP w0.127: v2(249.05,158.13) 249.81,157.37 R345.2 251.25,158.07 251.45,158.27 R338.2 ; v2(239.65,145.94) 235.71,145.94 233.6,143.83 233.6,138.5 v2(227.2,132.09) ; U50.3 192.47,92.66 192.47,93.44 192.77,93.74 197.05,93.74 198.04,94.73 198.04,100.78 199.56,102.29 207.1,102.29 208.28,101.11 208.28,97.93 v2(207.39,97.04)
  L03_SIG1 w0.127: v2(207.39,97.04) 211.2,97.04 212.09,97.93 212.09,100.9 218.01,106.82 223.34,106.82 224.23,105.93 227.2,105.93 227.76,106.49 227.76,110.84 v2(226.44,112.16)
  BOTTOM w0.127: v2(226.44,112.16) 227.51,113.22 227.51,131.79 v2(227.2,132.09) ; v2(239.65,145.94) 243.71,145.94 244.07,146.29 250.88,146.29 252.53,147.94 252.53,150.71 250.57,152.67 250.57,156.61 v2(249.05,158.13)
24MHZ_LVCMOS_USB0_CLK: length 8.1
  TOP w0.104: R489.1 153.53,87.75 153.23,87.45 148.97,87.45 147.9,88.52 147.13,88.52 146.98,88.67 U62.29
24MHZ_LVCMOS_USB1_CLK: length 8.1
  TOP w0.104: U62.28 147.02,88.17 147.12,88.28 147.8,88.28 148.87,87.21 153.45,87.21 153.53,87.14 R488.1
24MHZ_LVDS_N: length 5.2
  TOP w0.102: U62.25 147.06,86.67 147.15,86.76 147.44,86.76 147.68,86.52 147.68,85.4 148.12,84.95 149.58,84.95 149.72,84.82 R22.1
24MHZ_LVDS_P: length 5.2
  TOP w0.102: R21.1 149.72,85.42 149.58,85.28 148.26,85.28 148.01,85.54 148.01,86.65 147.57,87.09 147.15,87.09 147.06,87.17 U62.26
100MHZ_HCSL_N: length 8
  TOP w0.102: R891.1 153.78,92.87 153.53,92.62 151.43,92.62 150.9,92.09 147.15,92.09 147.06,92.17 U62.36
100MHZ_HCSL_P: length 8.1
  TOP w0.102: R890.1 153.78,92.18 153.67,92.29 151.57,92.29 151.04,91.76 147.15,91.76 147.06,91.67 U62.35
100MHZ_LVDS_N: length 9.7
  TOP w0.102: U62.21 144.25,85.26 144.14,85.16 144.14,82.39 145.07,81.46 148.67,81.46 148.83,81.29 149,81.29 149.08,81.38 R18.1
100MHZ_LVDS_P: length 9.7
  TOP w0.102: R17.1 148.49,81.13 144.94,81.13 143.81,82.25 143.81,85.19 143.75,85.26 U62.20
250MHZ_LVDS_CPTS_REF_CLKN: length 46
  TOP w0.102: U1.L21 v1(175.61,113.01) ; v2(152.58,90.53) 152.58,90.53 152.58,90.24 152.48,90.14 151.95,90.14 R24.2
  L03_SIG1 w0.102: v1(175.61,113.01) 175.46,113.16 174.89,113.16 174.42,112.69 173.74,112.69 173.56,112.51 173.56,110.25 172.06,108.75 168.15,108.75 167.67,108.27 167.67,107.91 167.13,107.38 165.4,107.38 163.88,105.86 163.88,104.61 161.65,102.38 154.36,102.38 152.81,100.83 152.81,94.58 151.69,93.46 151.69,90.46 152.06,90.1 153.02,90.1 153.16,90.24 153.16,90.41 153.04,90.53 v2(152.58,90.53)
250MHZ_LVDS_CPTS_REF_CLKP: length 46
  TOP w0.102: R23.2 151.79,89.81 152.34,89.81 v2(152.53,89.63) ; U1.K21 v1(176.41,113.01)
  L03_SIG1 w0.102: v2(152.53,89.63) 152.32,89.83 151.95,89.83 151.42,90.35 151.42,93.57 152.54,94.69 152.54,100.94 154.25,102.64 161.54,102.64 163.61,104.72 163.61,105.97 165.29,107.65 167.02,107.65 167.4,108.02 167.4,108.38 168.04,109.02 171.95,109.02 173.29,110.36 173.29,112.62 173.63,112.96 174.31,112.96 174.78,113.43 176,113.43 v1(176.41,113.01)
250MHZ_LVDS_N: length 4.2
  TOP w0.102: R24.1 149.97,90.37 149.82,90.22 148.15,90.22 147.78,90.59 147.15,90.59 147.06,90.67 U62.33
250MHZ_LVDS_P: length 4.2
  TOP w0.102: R23.1 149.97,89.79 149.87,89.89 148.01,89.89 147.64,90.26 147.15,90.26 147.06,90.17 U62.32
ATTENTIONZ: length 68.7
  TOP w0.127: SW7.1 SW7.2 91.22,239.05 90.87,238.7 D10.1 ; v1(72.51,199) 72.51,199 72.68,199.18 72.88,199.18 U20.D6 ; R289.1 91.97,238.15 91.83,238.01 D10.1 ; D10.1 v2(89.79,238.01)
  BOTTOM w0.127: v1(72.51,199) 72.51,199.68 70.13,202.06 70.13,207.32 72.54,209.73 72.54,216.39 74.44,218.29 74.44,218.29 74.93,218.78 79.13,222.98 79.13,237.48 80.68,239.03 89.6,239.03 89.73,238.91 v2(89.79,238.01)
AUD_AGND: length 37.8
  TOP w0.203: U96.26 280,37.39 v2(280.03,37.35) ; U96.15 273.84,37.89 U96.49 ; U96.20 276.34,38.89 U96.49 ; U96.49 275.51,39.64 v2(275.49,39.66) ; U96.21 276.84,37.33 v2(277.5,37.99)
  TOP w0.381: v2(292.15,10.02) 292.11,10.06 J33.1 294.23,12 v2(294.31,12.08) ; 267.92,35.32 267.92,35.91 267.33,36.49 267.33,39.59 269.67,41.92 270.46,41.92 270.48,41.9 ; FB41.1 v2(286.38,32.91) ; v2(276.68,11.98) 276.7,12 J32.1 278.77,10.06 v2(278.94,9.9) ; C339.2 v2(284.86,36.08)
  BOTTOM w0.381: C702.2 v2(273.82,32.79) ; C695.2 279.63,36.25 279.63,36.95 v2(280.03,37.35) ; C687.1 v2(270.26,35.07) ; C691.1 v2(271.91,35.19)
  BOTTOM w0.508: C696.2 276.24,37.34 v2(275.59,37.99)
  vias: v2(271.83,19.73) v2(273.69,40.91) v2(273.69,39.64) v2(273.81,37.99) v2(275.46,40.91) v2(277.24,40.91) v2(277.5,39.64) v2(285.62,32.91)
AUD_BUFF_CLK_DIR: length 4.4
  BOTTOM w0.127: R502.2 R492.2 197.37,153.95 197.23,153.81 197.23,153.6 197.22,153.59 U136.2
AUD_BUFF_DAT_DIR: length 9.1
  BOTTOM w0.127: U136.3 197.87,153.93 198.5,154.55 198.5,155.08 199.14,155.72 200.25,155.72 201.01,154.95 R911.2 201.66,155.5 202,155.84 202.75,155.84 202.96,156.06 R910.2
AUD_BUFF_EN: length 43.3
  TOP w0.127: R796.2 228.04,144.64 227.63,145.05 SW15.2 v2(226.69,143.45)
  L03_SIG1 w0.127: v2(197.36,145.18) 197.36,144.64 202.29,139.71 205.82,139.71 207.75,141.65 224.89,141.65 v2(226.69,143.45)
  BOTTOM w0.127: v2(197.36,145.18) 197.36,145.62 197.22,145.75 U136.15 197.22,147.99 197.33,148.1 197.76,148.1 197.87,147.98 U136.14
AUD_MCLK_R: length 3.4
  TOP w0.127: R537.2 278.38,45.71 278.59,45.5 278.59,43.83 278.34,43.58 U96.37
AUDIO_RSTN: length 401.8
  TOP w0.127: 89.92,172.66 89.92,174.54 v2(89.54,174.93) R275.1 ; U97.1 v2(286.35,36.51)
  L08_SIG2 w0.127: v2(286.35,36.51) 285.56,37.3 284.78,37.3 283.34,38.75 281.43,38.75 281.39,38.8 281.37,38.8 280.42,39.75 280.42,39.77 277.89,42.29 269.4,42.29 266.55,39.45 266.55,24.88 263.2,21.53 200.4,21.53 198.45,23.48 186.51,23.48 182.02,27.98 161.57,27.98 158.07,24.48 155.52,24.48 152.46,21.43 140.49,21.43 138.71,23.21 126.59,23.21 125.12,24.68 110.31,24.68 108.66,26.33 96.17,26.33 84.2,38.3 84.2,55.39 81.13,58.46 v2(81.13,60.14)
  BOTTOM w0.127: v2(81.13,60.14) 79.44,60.14 76.19,63.39 76.19,114.85 65.92,125.11 65.92,135.32 68.41,137.81 68.41,140.96 94.59,167.14 94.59,175.02 93.67,175.95 90.55,175.95 v2(89.54,174.93)
AUDIO_RSTN_AND: length 10.8
  TOP w0.127: U97.4 288.25,39.33 288.16,39.23 281.84,39.23 280.18,40.89 U96.33
BMC_AUDIO_RSTN: length 46.3
  TOP w0.102: U20.K19 79.45,196.23 79.81,195.87 80.81,195.87 80.86,195.82 80.89,195.82
  TOP w0.127: U35.5 89.42,167.95 v2(88.92,167.45) ; R193.1 v2(86.78,194.71) 86.27,195.21 86.24,195.21 86.23,195.23 85.41,195.23 85.15,194.97 81.75,194.97 80.89,195.82
  L08_SIG2 w0.127: v2(86.78,194.71) 86.09,195.39 85.83,195.39 85.39,194.96 83.69,194.96 83.32,194.59 83.32,190 83.32,171.2 83.65,170.87 83.65,170.87 87.59,166.93 88.4,166.93 v2(88.92,167.45)
BMC_BLUE_LED: length 84.8
  TOP w0.127: v1(72.01,196.74) 71.72,196.45 71.65,196.45 U20.K3
  L03_SIG1 w0.102: v1(72.01,196.74) 72.4,197.13 72.98,197.13 73.66,197.81 73.66,198.86 74.04,199.24 74.04,200.78 72.27,202.55
  L03_SIG1 w0.127: v2(53.34,205.88) 54.14,205.88 54.36,205.67 54.36,204.42 56.51,202.26 58.66,202.26 61.7,205.3 69.53,205.3 72.27,202.55
  BOTTOM w0.127: v2(53.34,205.88) 52.96,206.26 52.96,213.83 50.37,216.42 39.75,216.42 30.23,225.95 30.23,233.44 27.89,235.78 24.37,235.78 23.37,236.78 R602.2
BMC_BOOTMODE0: length 224.5
  TOP w0.127: U20.D12 75.93,198.88 v2(75.57,198.52) ; v2(172.97,79.52) 172.97,79.96 173.27,80.26 173.27,86.82 173.21,86.88 U67.43
  L08_SIG2 w0.127: v2(75.57,198.52) 75.86,198.81 75.86,199.89 75.18,200.57 70.89,200.57 69.85,199.53 69.39,199.53 66.64,196.78 66.64,195.71 66.64,195.15 66.43,194.95 66.43,186.8 57.76,178.13 57.76,170.38 66.29,161.86 66.29,159.09 104.01,121.37 104.01,93.81 111.48,86.35 112.63,86.35 120.9,78.08 132.67,78.08 132.87,77.88 137.6,77.88 138.18,78.45 141.55,78.45 142.19,79.08 172.54,79.08 v2(172.97,79.52)
BMC_BOOTMODE1: length 200.2
  TOP w0.102: U20.R13 76.58,193.88 v1(76.58,194.15)
  TOP w0.127: U67.40 172.01,86.88 172.07,86.82 172.07,80.26 v2(171.83,80.02)
  L08_SIG2 w0.102: 75.84,190.16 75.84,190.51 76.96,191.63 76.96,192.93 76.58,193.31 v1(76.58,194.15)
  L08_SIG2 w0.127: v2(171.83,80.02) 171.83,80.18 172.19,80.53 172.19,81.45 171.73,81.9 169.7,81.9 169.27,81.47 169.27,81.07 168.95,80.75 153.68,80.75 152.06,82.37 151.21,82.37 150.6,81.76 140.27,81.76 138.89,80.38 133.31,80.38 132.65,79.72 121.09,79.72 108.77,92.04 108.5,92.04 105.46,95.09 105.46,130.24 74.93,160.77 74.93,183.21 73.62,184.52 73.62,186.88 74.71,187.97 74.88,187.97 75.84,188.94 75.84,190.16
BMC_BOOTMODE2: length 225.3
  TOP w0.127: v2(173.74,79.39) 173.74,80.1 173.55,80.28 173.55,86.82 173.61,86.88 U67.44 ; U20.D13 v1(76.43,199.74)
  L08_SIG2 w0.127: v2(173.74,79.39) 173.15,78.8 142.34,78.8 141.71,78.17 138.25,78.17 137.72,77.64 132.77,77.64 132.57,77.84 120.8,77.84 112.9,85.74 111.75,85.74 103.48,94.01 103.48,121.57 65.79,159.26 65.79,161.97 57.52,170.23 57.52,178.23 66.19,186.9 66.19,191.88 66.14,191.93 66.14,195 66.4,195.25 66.4,195.81 66.4,197.2 69.01,199.81 69.62,199.81 70.64,200.83 75.34,200.83 v1(76.43,199.74)
BMC_BOOTMODE3: length 240.8
  TOP w0.102: U20.A14 76.63,201.03 76.63,201.69 77.37,202.43 77.37,202.55
  TOP w0.127: v2(174.5,77.74) 174.94,78.18 174.94,78.98 174.75,79.16 174.75,86.42 174.75,86.43 174.75,86.83 174.81,86.89 U67.47 ; v2(77.37,202.71) 77.37,202.55
  L08_SIG2 w0.127: v2(174.5,77.74) 173.99,78.24 142.7,78.24 141.2,76.75 132.66,76.75 132.11,77.31 120.57,77.31 112.64,85.24 108.57,85.24 102.92,90.9 102.92,120.35 81.46,141.8 80.83,141.8 70.85,151.78 64.39,151.78 60.58,155.59 60.58,157.62 56.77,161.43 56.77,162.69 57,162.92 57,179.55 64.85,187.4 64.85,187.9 65.71,188.76 65.71,191.68 65.2,192.19 65.2,195.84 65.89,196.52 65.89,197.96 71.65,203.72 76.96,203.72 77.39,203.29 77.39,202.73 v2(77.37,202.71)
BMC_BOOTMODE4: length 202.4
  TOP w0.102: 76.1,194.27 76.1,193.59 76.43,193.26
  TOP w0.127: 76.43,193.26 U20.T13 ; U67.37 170.81,86.88 170.87,86.82 170.87,81.67 170.56,81.36 v2(170.56,80.91) ; v2(75.97,194.4) 76.1,194.27
  L08_SIG2 w0.102: v2(75.97,194.4) 75.92,194.35 75.31,194.35 75.18,194.22 75.18,194.17 74.56,193.54 74.56,193.53 74.31,193.28 73.41,193.28 72.92,192.8 72.92,191.99 72.12,191.19 72.12,190.16
  L08_SIG2 w0.127: 72.12,190.16 72.12,184.81 74.09,182.84 74.09,160.42 104.62,129.89 104.62,93.94 111.56,87 112.66,87 121.06,78.6 121.08,78.6 121.11,78.58 132.87,78.58 133.07,78.37 137.12,78.37 137.8,79.06 141.34,79.06 141.92,79.64 170.79,79.64 171.58,80.43 171.6,80.43 171.93,80.76 171.93,81.24 171.63,81.55 171.2,81.55 v2(170.56,80.91)
BMC_BOOTMODE5: length 235
  TOP w0.102: U20.B14 76.95,200.23 77.22,200.5 77.22,201.26 v2(77.04,201.44)
  TOP w0.127: U67.46 174.41,86.88 174.47,86.82 v2(174.47,78.78)
  L08_SIG2 w0.127: v2(174.47,78.78) 174.02,78.78 173.76,78.52 142.52,78.52 140.98,76.99 132.98,76.99 132.38,77.59 120.7,77.59 120.68,77.61 120.65,77.61 112.78,85.49 108.97,85.49 103.2,91.25 103.2,120.46 71.44,152.22 65.98,152.22 63.25,154.95 63.25,158.38 58.65,162.98 58.65,168.71 57.28,170.08 57.28,179.44 65.13,187.29 65.13,187.78 65.95,188.61 65.95,191.78 65.74,192 65.74,194.96 66.14,195.37 66.14,197.8 70.94,202.61 74.57,202.61 75.13,202.05 76.43,202.05 v2(77.04,201.44)
BMC_BOOTMODE6: length 195.8
  TOP w0.127: U67.38 171.21,86.88 171.15,86.82 171.15,81.68 171.45,81.38 v2(171.45,80.91) ; v1(74.78,193.21) 74.9,193.08 74.9,192.76 U20.U10
  L08_SIG2 w0.102: 73.96,190.16 73.96,190.57 74.98,191.58 74.98,192.85 74.78,193.05 v1(74.78,193.21)
  L08_SIG2 w0.127: 73.96,190.16 73.96,188.19 72.4,186.63 72.4,184.92 74.37,182.96 74.37,160.54 104.9,130.01 104.9,94.06 111.67,87.29 112.75,87.29 121.22,78.82 133.06,78.82 133.25,78.63 136.98,78.63 137.69,79.34 141.23,79.34 141.81,79.92 170.46,79.92 v2(171.45,80.91)
BMC_BOOTMODE7: length 200.1
  TOP w0.102: v1(69.51,193.93) 69.93,193.93 70.24,194.23 U20.P2
  TOP w0.127: U67.41 172.41,86.88 172.35,86.82 172.35,80.52 v2(172.59,80.28)
  L08_SIG2 w0.127: v2(172.59,80.28) 172.47,80.15 172.47,79.96 171.87,79.36 142.04,79.36 141.46,78.78 137.92,78.78 137.26,78.12 132.97,78.12 132.77,78.32 121,78.32 112.64,86.68 111.49,86.68 104.34,93.83 104.34,129.5 73.81,160.04 73.81,179.19 70.5,182.5 70.5,192.94 v1(69.51,193.93)
BMC_BOOTMODE8: length 188.1
  TOP w0.102: U20.V9 74.43,192.2 74.13,191.9 74.13,190.79 73.96,190.63 73.96,190.16
  TOP w0.127: v1(74.7,185.89) 73.96,186.63 73.96,190.16 ; v2(169.04,82.44) 169.15,82.56 169.15,86.82 169.21,86.88 U67.33
  L08_SIG2 w0.127: v1(74.7,185.89) 74.7,185.82 75.49,185.03 75.49,161 106.02,130.47 106.02,95.26 108.07,93.21 108.39,93.21 121.36,80.24 132.17,80.24 132.87,80.94 138.61,80.94 140.16,82.49 150.22,82.49 150.77,83.05 152.37,83.05 154.15,81.27 167.25,81.27 168.42,82.44 v2(169.04,82.44)
BMC_BOOTMODE9: length 195.9
  TOP w0.102: 72.06,194.62 71.95,194.73 U20.N4
  TOP w0.127: 72.06,194.62 v2(72.43,194.25) ; U67.30 168.01,86.88 167.95,86.82 167.95,84.54 v2(168.4,84.09)
  L08_SIG2 w0.102: v2(72.43,194.25) 72.85,194.25 73.36,193.74 73.71,193.74 73.79,193.82 73.79,193.84 74.02,194.06 74.03,194.06 74.17,194.2 74.42,194.2 74.86,194.63 74.86,194.78 75.18,195.11 75.87,195.11 76.23,194.76 76.23,194.75 76.45,194.53 76.93,194.53 77.11,194.71 77.75,194.71 78.79,193.66 78.79,192.66 77.19,191.06 77.19,190.82 76.84,190.47 76.84,190.16
  L08_SIG2 w0.127: v2(168.4,84.09) 168.4,83.52 167.87,82.99 164.75,82.99 163.06,84.69 155.16,84.69 154.23,83.76 150.34,83.76 149.96,83.38 134.4,83.38 131.83,80.8 121.6,80.8 108.41,93.99 108.08,93.99 106.53,95.55 106.53,130.77 76.33,160.97 76.33,161.02 76.33,189.01 76.84,189.52 76.84,190.16
BMC_BOOTMODE10: length 189.4
  TOP w0.102: 74.65,191.09 74.65,191.51 U20.W9
  TOP w0.127: 74.65,191.09 74.65,190.46 74.22,190.03 74.22,187.83 75.13,186.91 75.13,185.64 v1(74.55,185.05) ; v2(170.07,82.44) 170.07,86.82 170.01,86.88 U67.35
  L08_SIG2 w0.127: v2(170.07,82.44) 169.75,82.44 168.3,80.99 153.93,80.99 152.27,82.64 150.95,82.64 150.47,82.16 140.26,82.16 138.76,80.66 133.19,80.66 132.5,79.96 121.25,79.96 108.51,92.7 108.19,92.7 105.74,95.15 105.74,130.35 75.21,160.88 75.21,184.39 v1(74.55,185.05)
BMC_BOOTMODE11: length 193.2
  TOP w0.127: v2(170.05,81.42) 170.54,81.91 170.54,82.84 170.35,83.03 170.35,86.82 170.41,86.88 U67.36 ; v1(75.39,193.36) 75.02,193.73 U20.R10
  L08_SIG2 w0.102: v1(75.39,193.36) 76,192.75 76,191.96 75.51,191.48 75.51,190.16
  L08_SIG2 w0.127: v2(170.05,81.42) 169.95,81.32 169.95,80.66 169.49,80.2 141.58,80.2 141.48,80.1 133.43,80.1 132.81,79.48 120.94,79.48 108.89,91.53 108.68,91.53 105.18,95.02 105.18,130.12 74.65,160.65 74.65,183.07 73.38,184.34 73.38,187.14 75.51,189.27 75.51,190.16
BMC_BOOTMODE12: length 192.3
  TOP w0.127: U20.N5 72.6,194.73 72.65,194.67 v2(72.92,194.67) ; U67.29 167.61,86.88 167.67,86.82 v2(167.67,83.48)
  L08_SIG2 w0.102: v2(72.92,194.67) 73.09,194.51 73.79,194.51 74.05,194.76 74.05,194.91 74.61,195.47 76.17,195.47 76.29,195.35 76.8,195.35 77.24,194.91 77.98,194.91 78.16,195.09 78.94,195.09 79.2,194.83 79.2,192.73 78.84,192.38 78.84,192.09 78.54,191.78 78.2,191.78 77.39,190.98 77.39,190.64 77.25,190.5 77.25,190.16
  L08_SIG2 w0.127: v2(167.67,83.48) 167.22,83.48 167.06,83.31 164.86,83.31 163.09,85.08 155.21,85.08 154.27,84.14 150.88,84.14 149.53,85.49 135.13,85.49 133.01,87.61 115.23,87.61 111.84,91 111.84,91.61 106.77,96.67 106.77,130.92 76.57,161.12 76.57,188.32 77.25,189.01 77.25,190.16
BMC_BOOTMODE13: length 191.1
  TOP w0.102: 73.66,190.16 73.66,190.68 73.93,190.95 U20.V8
  TOP w0.127: v1(74.07,185.61) 73.7,185.98 73.7,187.71 73.66,187.75 73.66,190.16 ; v2(168.66,83.07) 168.66,83.52 168.87,83.73 168.87,86.82 168.81,86.88 U67.32
  L08_SIG2 w0.127: v2(168.66,83.07) 167.13,81.55 154.31,81.55 152.37,83.48 150.55,83.48 150.16,83.1 134.52,83.1 131.94,80.52 121.48,80.52 108.51,93.49 108.18,93.49 106.29,95.39 106.29,130.61 75.83,161.07 75.83,186.59 75.08,187.34 74.47,187.34 73.86,186.73 73.86,185.82 v1(74.07,185.61)
BMC_BOOTMODE14: length 195.1
  TOP w0.102: U20.N2 70.93,194.69 70.71,194.48 70.57,194.48 70.55,194.45 70.31,194.45 70.29,194.48 v1(69.93,194.48)
  TOP w0.127: v2(167.13,84.22) 166.75,84.59 166.75,86.82 166.81,86.88 U67.27
  L08_SIG2 w0.102: 77.6,190.16 77.6,190.9 78.28,191.58 78.89,191.58 79.04,191.73 79.04,192.29 79.48,192.72 79.48,194.99 79.17,195.29 77.99,195.29 77.83,195.12 77.35,195.12 76.94,195.53 76.94,195.78 76.6,196.11 76.08,196.11 75.69,195.72 74.14,195.72 73.69,195.27 73.36,195.27 73.17,195.08 72.76,195.08 72.69,195.01 72.34,195.01 71.84,194.51 71.84,194.49 71.6,194.25 71.58,194.25 71.42,194.1 70.31,194.1 v1(69.93,194.48)
  L08_SIG2 w0.127: 77.6,190.16 77.6,188.94 76.91,188.25 76.91,161.12 107.01,131.02 107.01,96.79 112.09,91.71 112.09,91.09 115.29,87.89 133.24,87.89 135.03,86.1 154.66,86.1 155.4,85.36 163.58,85.36 165.34,83.59 166.51,83.59 v2(167.13,84.22)
