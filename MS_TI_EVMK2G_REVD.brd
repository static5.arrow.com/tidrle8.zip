# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_EHRPWM5B: length 200.9
  TOP w0.127: U1.E16 v1(179.61,116.21)
  L08_SIG2 w0.102: v1(179.61,116.21) 180.83,114.99 180.83,114.44 181.07,114.19 182.29,114.19 182.8,113.68 187.2,113.68 187.59,114.07 189.1,114.07
  L08_SIG2 w0.127: v2(209.55,108.47) 209.55,108.66 208.68,109.53 208.68,109.55 208.41,109.82 206.4,109.82 202.95,113.27 197.03,113.27 196.23,114.07 189.1,114.07
  BOTTOM w0.127: v2(209.55,108.47) 209.86,108.79 214.69,108.79 218.19,112.28 218.19,117.66 220.12,119.59 220.12,134.7 221.89,136.48 240.55,136.48 246.77,130.25 269.07,130.25 286.56,147.74 286.56,176.98 298.07,188.48 298.07,193.49 299.5,194.91 301.36,194.91 J12.36
SOC_EHRPWM_TRIPZONE_INPUT3: length 219.1
  TOP w0.127: U1.H24 178.01,109.81 v1(178.01,108.14)
  L03_SIG1 w0.127: v2(230.12,131.97) 230.66,132.5 252.78,132.5 254.77,130.51 273.89,130.51 278.02,134.63 279.15,134.63 280.29,133.49 v2(281.81,133.49) ; v2(232.49,111.8) 230.04,109.35 230.04,106.37 228,104.33 221.48,104.33 212.18,95.04 209.43,95.04 207.52,93.12 195.31,93.12 193.8,94.63 192.2,94.63 190.46,96.37 188.4,96.37 187.36,97.42 187.36,99.54 187.11,99.79 185.34,99.79 v2(184.75,99.2)
  L08_SIG2 w0.127: v2(281.81,133.49) 285.75,137.43 285.75,178.83 298.17,191.25 J12.37
  BOTTOM w0.102: 180.97,104.03 180.57,104.43 179.2,104.43 178.98,104.65 178.98,107.8 178.64,108.14 v1(178.01,108.14)
  BOTTOM w0.127: 180.97,104.03 183.25,101.75 183.25,101.37 184.47,100.15 184.47,99.54 184.81,99.2 184.76,99.15 184.76,99.2 v2(184.75,99.2) ; v2(232.49,111.8) 232.49,112.56 230.76,114.29 230.76,130.82 230.12,131.46 v2(230.12,131.97)
SOC_EHRPWM_TRIPZONE_INPUT4: length 181.1
  TOP w0.127: U1.E13 v1(179.61,118.61)
  L08_SIG2 w0.102: v1(179.61,118.61) 180,118.23 182.6,118.23 183.01,118.63 189.05,118.63 189.1,118.58
  L08_SIG2 w0.127: 189.1,118.58 189.43,118.58 189.7,118.85 190.51,118.85 192.81,116.55 194.67,116.55 197.96,119.84 203.09,119.84 203.75,120.5 221.91,120.5 222,120.41 v2(223.01,120.41)
  BOTTOM w0.127: J12.46 301.24,179.84 301.24,178.15 300.4,177.31 294.13,177.31 288.8,171.97 288.8,146.82 270,128.02 245.25,128.02 238.81,134.46 223.09,134.46 222.82,134.19 222.82,133.2 223.01,133.01 v2(223.01,120.41)
SOC_EHRPWM_TRIPZONE_INPUT5: length 190.5
  TOP w0.127: U1.F16 v1(178.81,116.21)
  L08_SIG2 w0.102: 189.1,116.16 188.5,115.56 183.51,115.56 182.45,116.63 179.22,116.63 v1(178.81,116.21)
  L08_SIG2 w0.127: v2(219.63,117.06) 217.68,119.01 203.94,119.01 201.71,116.78 201.56,116.78 201.56,116.78 201.18,116.78 201.1,116.85 198.82,116.85 198.74,116.78 197.68,116.78 196.41,115.51 196.4,115.51 196.3,115.41 191.07,115.41 190.18,116.3 189.24,116.3 189.1,116.16
  BOTTOM w0.127: v2(219.63,117.06) 221.06,118.48 221.06,134.45 222.36,135.75 239.65,135.75 245.99,129.42 269.42,129.42 287.4,147.4 287.4,175.11 299.63,187.34 300.27,187.34 301.24,188.31 301.24,190 J12.38
SOC_EMU00: length 46.7
  TOP w0.127: J19.19 v2(220.68,83.07)
  L08_SIG2 w0.127: v2(204.39,100.93) 204.39,100.92 204.56,101.08 205.51,101.08 205.82,100.78 205.82,100.21 206.16,99.86 209.73,99.86 210.24,99.35 211.88,99.35 213.87,97.37 213.87,92.88 213.69,92.7 213.69,91.12 214.84,89.97 215.8,89.97 217.37,88.4 217.37,86.77 218.71,85.43 218.71,84.36 219.1,83.96 219.35,83.96 219.48,84.09 219.48,84.75 219.61,84.88 219.86,84.88 219.99,84.75 219.99,84.09 220.12,83.96 221.18,83.96 221.31,83.83 221.31,83.23 221.16,83.07 v2(220.68,83.07)
  BOTTOM w0.127: U37.4 221.67,79.28 220.7,80.25 220.7,83.05 v2(220.68,83.07) ; R350.2 207.21,101.97 206.98,101.74 205.21,101.74 v2(204.39,100.93) 204.39,99.72 204.6,99.51 R351.2
SOC_EMU01: length 44.6
  TOP w0.127: J19.21 v2(220.18,82.31)
  L08_SIG2 w0.127: v2(220.18,82.31) 220.64,81.85 221.37,81.85 221.64,82.12 221.64,83.91 220.09,85.46 219.23,85.46 217.68,87.01 217.68,88.43 215.86,90.25 214.9,90.25 213.93,91.22 213.93,92.51 214.25,92.83 214.25,97.33 211.26,100.32 v2(206.35,100.32)
  BOTTOM w0.127: R355.2 206.35,99.19 v2(206.35,100.32) 206.45,100.22 206.88,100.22 207.31,99.79 R352.2 ; v2(220.18,82.31) 220.34,82.15 220.34,76.55 220.57,76.32 221.13,76.32 221.46,76.65 221.46,77.21 221.59,77.33 U37.7
SOC_GPIO0_102: length 226.2
  TOP w0.127: v1(72.64,196.74) 72.15,197.23 U20.H4 ; U1.P4 v1(173.21,126.61)
  L03_SIG1 w0.102: v1(173.21,126.61) 173.21,126.88 172.8,127.29 172.8,130.18 171.96,131.02 171.96,133.36 172.8,134.2 172.8,134.89
  L03_SIG1 w0.127: v2(170.61,194.05) 172.24,194.05 173.48,192.8 173.48,183.5 170.38,180.4 170.38,170.06 171.46,168.98 171.46,148.27 172.19,147.55 172.19,142.13 171.63,141.57 171.63,138.01 172.8,136.84 172.8,134.89 ; v2(165.99,208.8) 134.8,208.8 122.1,221.5 80.95,221.5 75.62,216.17 75.62,216.14 75.29,215.81 67.54,215.81 v2(65.53,217.82)
  BOTTOM w0.102: v1(72.64,196.74) 72.14,197.25 69.6,197.25
  BOTTOM w0.127: v2(165.99,208.8) 165.99,198.67 v2(170.61,194.05) ; v2(65.53,217.82) 65.22,217.51 65.22,201.37 69.34,197.25 69.6,197.25
SOC_GPMC_AD0: length 68.9
  TOP w0.127: U1.AC21 v1(165.21,112.21)
  L08_SIG2 w0.102: v1(165.21,112.21) 165.02,112.03 165.02,112.03 164.98,112 164.97,112 164.62,111.66 164.62,111.64 164.31,111.33 164.19,111.21 164.19,111.2 163.73,110.73 163.73,110.49 163.69,110.45 163.69,108.86 162.43,107.61 161.21,107.61
  L08_SIG2 w0.127: v2(115.7,124.22) 117.61,122.3 121.36,122.3 123.27,120.4 123.27,115.28 125.35,113.2 125.35,112.75 131.01,107.09 139.56,107.09 140.46,106.19 149.99,106.19 150.5,105.68 154.99,105.68 155.26,105.95 156.38,105.95 158.15,107.72 160.95,107.72 161.06,107.61 161.21,107.61
  BOTTOM w0.127: U87.29 115.25,126.71 115.7,126.27 v2(115.7,124.22)
SOC_GPMC_AD1: length 61.7
  TOP w0.127: U1.AE20 163.89,113.29 162.56,113.29 162.32,113.53 161.99,113.53 v1(161.47,113.01)
  L08_SIG2 w0.127: v2(115.94,126.76) 123.12,126.76 125.78,124.1 126.97,122.9 126.97,116.36 132.8,110.53 146.02,110.53 146.65,111.15 148.09,111.15 148.51,110.73 154.09,110.73 154.39,111.04 154.4,111.04 154.45,111.09 155.3,111.09 157.22,113.01 v1(161.47,113.01)
  BOTTOM w0.127: v2(115.94,126.76) 115.75,126.95 U87.30
SOC_GPMC_AD2: length 66.4
  TOP w0.127: v1(162.74,111.41) 164.41,111.41 U1.AD22
  L08_SIG2 w0.102: v1(162.74,111.41) 162.45,111.13 162.45,109.74 161.57,108.85 161.21,108.85
  L08_SIG2 w0.127: 161.21,108.85 155.45,108.85 154.86,108.27 149.05,108.27 148.15,107.37 140.91,107.37 140.07,108.21 131.47,108.21 126.49,113.18 126.49,113.68 124.69,115.48 124.69,122.03 123.71,123 119.56,123 117.98,124.58 117.08,124.58 v2(116.71,124.22)
  BOTTOM w0.127: v2(116.71,124.22) 116.21,124.73 116.21,126.18 116.46,126.43 116.46,127.01 116.25,127.22 U87.31
SOC_GPMC_AD3: length 62.2
  TOP w0.127: U1.AD20 164.41,113.01 v1(162.05,113.01)
  L08_SIG2 w0.102: v1(162.05,113.01) 161.6,112.56 161.21,112.56
  L08_SIG2 w0.127: v2(116.73,125.97) 118.08,125.97 118.08,125.97 123.05,125.97 123.51,125.97 125.66,123.82 126.7,122.79 126.7,116.24 132.69,110.25 146.15,110.25 146.77,110.87 147.97,110.87 148.39,110.45 154.2,110.45 154.51,110.76 154.52,110.76 154.57,110.81 156.03,110.81 157.12,111.9 157.86,111.9 158.52,112.56 161.21,112.56
  BOTTOM w0.127: U87.32 116.75,125.99 v2(116.73,125.97)
SOC_GPMC_AD4: length 58.2
  TOP w0.127: U1.AE21 160.73,112.61 159.64,111.52 v1(159.64,110.89)
  L08_SIG2 w0.127: v1(159.64,110.89) 159.64,110.63 158.98,109.97 154.94,109.97 154.58,109.62 147.98,109.62 147.57,110.04 147.18,110.04 146.52,109.37 132.38,109.37 125.86,115.9 125.86,122.44 125.81,122.49 123.69,124.6 121.86,124.6 v2(121.54,124.92)
  BOTTOM w0.127: U87.41 121.25,125.21 v2(121.54,124.92)
SOC_GPMC_AD5: length 58.2
  TOP w0.127: U1.AE22 161.87,111.81 v1(161.47,111.41)
  L08_SIG2 w0.102: v1(161.47,111.41) 161.21,111.41
  L08_SIG2 w0.127: v2(122.12,123.83) 122.62,124.32 123.58,124.32 125.2,122.7 125.58,122.32 125.58,115.73 132.3,109.01 140.4,109.01 140.43,108.98 148.53,108.98 148.78,109.23 154.61,109.23 155.07,109.69 159.21,109.69 160.15,110.63 160.15,111.14 160.42,111.41 161.21,111.41
  BOTTOM w0.127: U87.42 121.75,126.13 122.12,125.75 v2(122.12,123.83)
SOC_GPMC_AD6: length 62.2
  TOP w0.127: U1.AC20 v1(165.21,113.01)
  L08_SIG2 w0.102: v1(165.21,113.01) 164.99,112.8 164.97,112.8 164.62,112.46 164.62,112.44 163.68,111.5 163.4,111.5 163.1,111.2 163.08,111.2 163.05,111.17 163.04,111.17 162.9,111.03 162.88,111.03 162.75,110.9 162.75,110.87 162.74,110.86 162.74,110.37 162.75,110.36 162.75,109.72 161.6,108.57 161.21,108.57
  L08_SIG2 w0.127: 161.21,108.57 157.45,108.57 156.85,107.97 153.45,107.97 152.58,107.09 140.78,107.09 139.94,107.93 131.35,107.93 126.21,113.07 126.21,113.55 124.41,115.36 124.41,121.91 123.81,122.51 v2(123.16,122.51)
  BOTTOM w0.127: v2(123.16,122.51) 122.64,123.03 122.64,125.73 122.25,126.13 U87.43
SOC_GPMC_AD7: length 59.2
  TOP w0.127: v1(160.66,110.63) 160.66,111.77 161.09,112.21 164.41,112.21 U1.AD21
  L08_SIG2 w0.127: v2(123.16,123.83) 123.68,123.83 125.08,122.42 125.3,122.21 125.3,115.66 132.2,108.77 140.3,108.77 140.34,108.73 140.36,108.73 141.16,107.93 147.88,107.93 148.81,108.85 154.64,108.85 155.19,109.41 159.59,109.41 160.41,110.24 160.41,110.39 v1(160.66,110.63)
  BOTTOM w0.127: U87.44 122.75,126.25 123.16,125.84 v2(123.16,123.83)
SOC_GPMC_AD8: length 65.2
  TOP w0.127: U1.AE23 162.94,111.01 162.54,110.61 161.5,110.61 v1(161.48,110.63)
  L08_SIG2 w0.102: v1(161.48,110.63) 161.47,110.63 161.47,110.61 161.21,110.36 161.21,110.35
  L08_SIG2 w0.127: 161.21,110.35 159.99,109.13 155.32,109.13 154.74,108.55 148.92,108.55 148.02,107.65 141.03,107.65 140.33,108.35 140.32,108.35 140.18,108.49 132.08,108.49 124.97,115.6 124.97,122.14 123.83,123.28 119.68,123.28 118.1,124.86 114.89,124.86 v2(114.22,125.54)
  BOTTOM w0.127: U87.26 113.75,126 v2(114.22,125.54)
SOC_GPMC_AD9: length 67.1
  TOP w0.127: U1.AB20 v1(166.01,113.01)
  L08_SIG2 w0.102: 161.21,111.98 161.22,111.98 162.23,111.98 162.92,112.66 163.19,112.66 ; 164.59,113.4 165.62,113.4 v1(166.01,113.01)
  L08_SIG2 w0.127: 161.21,111.98 158.95,111.98 158.11,111.14 157.48,111.14 156.59,110.25 154.81,110.25 154.46,109.9 148.13,109.9 147.71,110.31 147.03,110.31 146.33,109.62 132.53,109.62 126.14,116.01 126.14,122.56 126.09,122.61 123.28,125.41 119.05,125.41 118.83,125.19 115.3,125.19 v2(115.03,125.46) ; 163.19,112.66 163.85,112.66 164.59,113.4
  BOTTOM w0.127: U87.27 114.25,126.24 v2(115.03,125.46)
SOC_GPMC_AD10: length 69.1
  TOP w0.127: U1.AA20 v1(167.61,113.01)
  L08_SIG2 w0.102: 164.97,114.2 166.97,114.2 167.2,113.97 167.2,113.43 v1(167.61,113.01) ; 163.07,112.98 162.71,112.98 161.99,112.26 161.34,112.26
  L08_SIG2 w0.127: 164.97,114.2 164.58,114.2 164.57,114.21 164.25,114.21 164.02,113.98 164.02,113.65 164.03,113.64 164.03,113.5 163.51,112.98 163.07,112.98 ; v2(115.02,126.2) 115.75,125.47 118.29,125.47 118.52,125.69 123.16,125.69 123.39,125.69 125.55,123.54 126.42,122.67 126.42,116.13 132.61,109.93 146.24,109.93 146.9,110.59 147.84,110.59 148.26,110.17 154.33,110.17 154.69,110.53 156.26,110.53 157.25,111.52 157.99,111.52 158.72,112.26 161.34,112.26
  BOTTOM w0.127: v2(115.02,126.2) 114.75,126.48 U87.28
SOC_GPMC_AD11: length 64.8
  TOP w0.127: v1(163.32,110.61) 164.41,110.61 U1.AD23
  L08_SIG2 w0.102: v1(163.32,110.61) 163.32,108.8 162.46,107.94 161.21,107.94
  L08_SIG2 w0.127: v2(117.6,124.09) 118.98,122.71 121.35,122.71 123.65,120.41 123.65,115.31 125.63,113.33 125.63,112.86 131.12,107.37 139.69,107.37 140.53,106.53 153.22,106.53 153.35,106.67 156.42,106.67 157.77,108.02 161.14,108.02 161.21,107.94
  BOTTOM w0.127: v2(117.6,124.09) 117.6,124.09 117.25,124.45 U87.33
SOC_GPMC_AD12: length 70.2
  TOP w0.127: U1.AA21 v1(167.61,112.21)
  L08_SIG2 w0.102: 164.36,110.97 164.36,111.08 164.4,111.11 164.4,111.12 164.83,111.55 164.83,111.57 165.05,111.8 165.07,111.8 165.1,111.83 167.22,111.83 v1(167.61,112.21)
  L08_SIG2 w0.127: 164.36,110.97 164.36,110.81 163.9,110.36 163.9,108.22 162.61,106.93 162.61,106.91 162.59,106.88 162.59,106.87 162.56,106.84 162.56,105.24 160.65,103.33 158.23,103.33 156.97,104.59 150.83,104.59 149.5,105.91 139.03,105.91 138.13,106.81 130.89,106.81 125.07,112.63 125.07,113.07 122.89,115.25 122.89,120.08 v2(121.29,121.68)
  BOTTOM w0.127: v2(121.29,121.68) 120.75,122.22 U87.40
SOC_GPMC_AD13: length 63.2
  TOP w0.127: U1.AB21 v1(166.01,112.21)
  L08_SIG2 w0.102: 161.21,108.3 161.28,108.23 162.06,108.23 162.07,108.22 162.39,108.22 162.95,108.79 162.95,110.44 162.94,110.46 162.94,110.77 163.16,111 163.47,111 164.83,112.35 164.83,112.37 165.05,112.59 165.37,112.59 165.38,112.58 165.64,112.58 v1(166.01,112.21)
  L08_SIG2 w0.127: v2(123.69,121.93) 124.03,121.59 124.03,115.32 125.93,113.42 125.93,112.95 131.24,107.65 139.81,107.65 140.65,106.81 153.07,106.81 153.21,106.95 156.31,106.95 157.66,108.3 161.21,108.3
  BOTTOM w0.127: v2(123.69,121.93) 123.69,126.01 123.25,126.45 U87.45
SOC_GPMC_AD14: length 68.1
  TOP w0.127: U1.AB22 v1(166.01,111.41)
  L08_SIG2 w0.102: v1(166.01,111.41) 165.62,111.02
  L08_SIG2 w0.127: 165.62,111.02 165.08,111.02 165.06,111.01 165.05,111.01 164.82,110.78 164.82,110.62 164.36,110.17 164.36,108.03 163.07,106.74 163.07,104.96 160.88,102.77 157.98,102.77 157.1,103.65 150.17,103.65 148.47,105.35 131.56,105.35 124.47,112.44 124.31,112.44 124.21,112.54 v2(124.21,112.79)
  BOTTOM w0.127: U87.46 123.75,126.58 124.21,126.13 v2(124.21,112.79)
SOC_GPMC_AD15: length 70.1
  TOP w0.127: U1.AA22 v1(166.81,111.41)
  L08_SIG2 w0.102: 165.38,110.2 166.21,110.2 166.4,110.38 166.4,111 v1(166.81,111.41)
  L08_SIG2 w0.127: 165.38,110.2 165.37,110.21 165.05,110.21 164.82,109.98 164.82,107.79 163.58,106.55 163.58,104.67 161.11,102.21 157.44,102.21 156.62,103.03 148.31,103.03 146.56,104.79 131.11,104.79 125.33,110.57 125.16,110.57 v2(124.84,110.89)
  BOTTOM w0.127: v2(124.84,110.89) 124.84,126.13 124.25,126.72 U87.47
SOC_GPMC_ALE: length 61.8
  TOP w0.127: U1.AC23 v1(165.21,110.61)
  L08_SIG2 w0.127: v1(165.21,110.61) 165.16,110.61 164.99,110.44 164.95,110.44 164.59,110.07 164.59,107.89 164.54,107.84 164.54,107.84 163.32,106.62 163.32,104.81 161,102.49 157.85,102.49 156.97,103.37 149.99,103.37 148.29,105.07 131.44,105.07 124.36,112.16 v2(117.86,112.16)
  BOTTOM w0.127: U87.17 116.75,110.03 117.86,111.14 v2(117.86,112.16)
SOC_GPMC_CLE: length 59
  TOP w0.127: U1.AC24 v1(165.21,109.81)
  L08_SIG2 w0.127: v1(165.21,109.81) 165.21,107.86 163.83,106.48 163.83,104.26 161.21,101.64 157.35,101.64 156.41,102.58 147.93,102.58 147.61,102.9 141.38,102.9 139.76,104.51 130.38,104.51 128.78,106.11 128.19,106.11 125.9,108.4 117.75,108.4 117.25,107.9 v2(117.25,107.35)
  BOTTOM w0.127: U87.16 v2(117.25,107.35)
SOC_GPMC_CSN0: length 57.4
  TOP w0.127: v1(166.81,105.6) 166.41,106 U1.AB25
  L08_SIG2 w0.102: 165.23,104.03 v1(166.81,105.6)
  L08_SIG2 w0.127: 165.23,104.03 161.98,100.78 156.09,100.78 154.57,99.25 151.71,99.25 150.84,100.12 142.86,100.12 141.92,101.06 141.91,101.06 141.17,101.79 129.54,101.79 125.81,105.53 122.07,105.53 v2(121.16,106.44)
  BOTTOM w0.127: U87.9 120.75,106.85 v2(121.16,106.44)
SOC_GPMC_RE#: length 59.7
  TOP w0.127: U1.AC22 v1(165.21,111.41)
  L08_SIG2 w0.102: 165.16,111.41 165.01,111.26
  L08_SIG2 w0.127: v2(121.79,113.55) 124.14,113.55 124.79,112.91 124.79,112.51 131.68,105.63 149.28,105.63 150.6,104.31 156.85,104.31 158.11,103.05 160.76,103.05 162.81,105.1 162.81,106.79 162.84,106.82 162.84,106.83 164.13,108.12 164.13,110.26 164.59,110.72 164.59,110.87 164.99,111.27 165.01,111.26 ; v1(165.21,111.41) 165.16,111.41
  BOTTOM w0.127: U87.8 121.25,113.01 v2(121.79,113.55)
SOC_GPMC_WAIT0: length 59.1
  TOP w0.127: U1.Y24 168.41,109.81 v1(168.41,108.14) ; v2(121.92,107.33) 122.36,107.33 122.38,107.34 122.6,107.34 122.81,107.55 R761.2
  L08_SIG2 w0.102: 164.59,105.55 166.5,107.46 167,107.46 167.69,108.14 v1(168.41,108.14)
  L08_SIG2 w0.127: v2(121.92,107.33) 123.06,106.19 126.62,106.19 128.47,104.33 128.47,103.42 129.82,102.07 141.3,102.07 142.01,101.36 148.34,101.36 148.84,100.85 149.64,100.85 149.92,100.57 155.5,100.57 155.98,101.06 161.52,101.06 164.59,104.13 164.59,105.55
  BOTTOM w0.127: U87.7 121.75,107.5 v2(121.92,107.33)
SOC_GPMC_WE#: length 65.1
  TOP w0.127: U1.Y22 v1(167.61,111.41)
  L08_SIG2 w0.102: v1(167.61,111.41) 167.22,111.03 167.22,109.32 164.08,106.19
  L08_SIG2 w0.127: v2(116.46,107.33) 116.97,106.82 117.48,106.82 117.75,107.1 117.75,107.85 118.02,108.12 125.65,108.12 127.94,105.83 128.63,105.83 128.91,105.55 128.91,103.49 130.05,102.35 141.43,102.35 142.14,101.64 147.8,101.64 148.42,102.26 155.94,102.26 156.84,101.36 161.43,101.36 164.08,104.01 164.08,106.19
  BOTTOM w0.127: U87.18 116.25,107.54 v2(116.46,107.33)
SOC_GPMC_WP#: length 67.3
  TOP w0.127: v1(166.81,103.52) 168.27,103.52 168.71,103.95 168.71,105.09 168.84,105.23 168.84,109.38 U1.W25 ; v2(115.44,107.08) 115.82,107.46 R760.2
  L08_SIG2 w0.127: v2(115.44,107.08) 117.53,104.99 125.76,104.99 129.29,101.46 141.1,101.46 141.78,100.78 141.81,100.78 142.76,99.82 150.1,99.82 150.95,98.97 154.69,98.97 156.21,100.5 162.24,100.5 165.27,103.52 v1(166.81,103.52)
  BOTTOM w0.127: v2(115.44,107.08) 115.75,107.38 U87.19
SOC_I2C0_SCL: length 385.4
  TOP w0.127: R800.2 v2(204.09,236.36) ; U16.2 v2(78.3,215.43) ; v2(165.73,151.54) 165.99,151.28 R366.1
  L03_SIG1 w0.127: v2(204.09,236.36) 204.09,235.7 210.59,229.2 210.59,213.22 209.89,212.52 209.89,206.86 210.59,206.16 210.59,197.32 203.2,189.93 203.2,179.54 194.63,170.97 v2(194.18,170.97)
  L08_SIG2 w0.127: v2(78.3,215.43) 82.5,215.43 90.04,207.89 90.04,202.2 94.17,198.07 94.17,192.36 94.74,191.78 106.43,191.78 106.88,192.24 154.36,192.24 154.6,192.24 163.35,183.49 163.35,153.81 165.62,151.54 v2(165.73,151.54) ; J12.28 301.26,205.18 299.16,205.18 273.3,231.03 257.56,231.03 254.38,234.2 228.55,234.2 226.39,236.36 222,236.36 218.44,232.81 207.2,232.81 204.09,235.92 v2(204.09,236.36)
  BOTTOM w0.127: v2(194.18,170.97) 194.6,170.97 194.86,170.72 R700.2 194.96,170.21 195.63,169.53 198.17,169.53 199.54,168.16 199.54,164.94 198.09,163.49 174.22,163.49 170.1,159.37 170.1,155.91 v2(165.73,151.54) 165.99,151.28 R366.1
SOC_I2C0_SDA: length 388.7
  TOP w0.127: U16.3 v2(77.65,216.21) ; R365.1 v2(164.47,151.36) ; R801.2 v2(204.09,234.84) ; R265.2 v2(193.73,171.74)
  L03_SIG1 w0.127: v2(193.73,171.74) 194.72,171.74 202.92,179.93 202.92,190.26 210.26,197.6 210.26,205.86 209.65,206.47 209.65,212.87 210.26,213.48 210.26,228.67 v2(204.09,234.84)
  L08_SIG2 w0.127: v2(204.09,234.84) 206.63,232.3 218.57,232.3 221.23,234.96 224.03,234.96 224.66,234.33 227.46,234.33 229.36,232.42 253.75,232.42 255.78,230.39 271.4,230.39 299.13,202.66 301.23,202.66 J12.30 ; v2(77.65,216.21) 77.65,215.1 78.11,214.64 81.48,214.64 89.54,206.59 89.54,199.74 91.54,197.73 91.54,191.56 92.37,190.73 94.31,190.73 94.98,191.41 106.56,191.41 107.11,191.96 154.48,191.96 162.99,183.45 162.99,155.91 163.09,155.81 163.09,152.73 v2(164.47,151.36)
  BOTTOM w0.127: R365.1 v2(164.47,151.36) 165.39,152.29 169.75,156.65 169.75,159.76 173.84,163.84 197.99,163.84 199.26,165.11 199.26,167.91 197.99,169.18 194.46,169.18 193.5,170.14 193.5,171.51 v2(193.73,171.74)
SOC_I2C1_SCL: length 679.3
  TOP w0.127: J21.3 68.03,53.72 68.2,53.55 v2(68.2,53.1) ; R553.2 v2(292.99,44.85) ; R803.1 198.88,100.9 199.81,101.83 v2(203.35,101.83) ; U96.1 271.57,42.39 271.4,42.56 271.4,43.65 267.49,47.56 v2(267.49,48.43) ; U112.1 157.28,145.25 157.16,145.13 157.16,144.4 v2(157.61,143.96) 157.92,143.64 157.92,143.46 160.27,141.11 162.56,141.11 162.94,141.49 162.94,144.85 163.16,145.06 R377.2 v2(163.7,145.98) ; v2(95.26,113.92) 94.07,113.92 93.73,113.58 U51.19 ; v2(96.92,29.5) U102.1
  L03_SIG1 w0.127: v2(203.35,101.83) 206.42,104.9 206.42,109.04 210.72,113.34 211.75,113.34 v2(212.24,112.84)
  L08_SIG2 w0.127: v2(68.2,53.1) 68.03,53.27 68.03,58.26 73.53,63.77 85.34,63.77 89.38,59.73 89.38,35.81 95.74,29.46 96.87,29.46 v2(96.92,29.5) ; v2(203.35,101.83) 208.83,101.83 209.52,101.13 211.13,101.13 214.76,97.5 214.76,92.94 215.24,92.46 215.24,90.99 215.44,90.8 216.16,90.8 217.79,89.17 217.79,89.16 218.49,88.47 218.59,88.47 218.6,88.46 219.3,88.46 219.31,88.47 221.89,88.47 221.9,88.46 222.6,88.46 222.61,88.47 222.71,88.47 222.98,88.74 223.85,88.74 224.36,88.23 225.25,88.23 225.82,87.66 225.82,86.93 226.59,86.16 226.59,80.49 224.49,78.38 224.49,70.19 226.12,68.55 226.12,65.34 224.84,64.06 224.84,50.96 225.73,50.07 225.73,40.3 226.44,39.59 226.44,37.58 228.71,35.31 231.41,35.31 234.65,32.07 234.65,30.51 236.29,28.87 238.43,28.87 238.85,29.29 240.98,29.29 241.3,29.61 249.58,29.61 250.6,30.62 251.66,30.62 255.5,34.46 255.5,35.91 266.43,46.84 266.43,47.81 267.06,48.43 v2(267.49,48.43)
  BOTTOM w0.127: v2(292.99,44.85) 291.16,44.85 283.92,52.08 272.9,52.08 269.24,48.43 v2(267.49,48.43) ; v2(212.24,112.84) 212.24,113.22 212.75,113.73 212.75,115.34 212.42,115.67 212.42,125.14 211.53,126.02 211.53,138.32 206.88,142.97 195.96,142.97 194.27,144.66 194.27,144.66 191.29,147.64 175.31,147.64 172.91,145.24 164.65,145.24 163.92,145.98 v2(163.7,145.98) R377.2 ; v2(157.61,143.96) 157.14,144.43 157.14,147.29 157.4,147.55 161.12,147.55 161.8,148.22 161.8,149.67 167.79,155.66 167.79,177.21 150.29,194.71 128.22,194.71 126.64,196.28 126.64,208.14 121.64,213.15 113.82,213.15 112.62,211.95 112.62,211.9 112.62,200.67 110.49,198.54 110.49,189.75 108.15,187.42 107.11,187.42 101.52,187.42 100.28,186.17 100.28,127.52 95.24,122.48 95.24,114.39 95.26,114.37 v2(95.26,113.92) 95.26,105.45 92.69,102.87 92.69,65.32 94.21,63.79 94.21,61.43 90.47,57.69 77.76,57.69 72.71,52.64 68.66,52.64 v2(68.2,53.1)
SOC_I2C1_SDA: length 669.9
  TOP w0.127: v2(69.09,53.1) 69.09,53.55 69.03,53.61 J21.4 ; v2(157.58,147.11) 157.28,147.4 U112.6 ; U102.2 97.42,29.24 v2(96.92,28.74) ; U51.20 93.23,113.92 93.51,114.2 94.32,114.2 v2(94.64,114.52) ; v2(202.41,101.11) 201.02,101.11 200.48,100.57 R804.1 ; U96.2 271.05,41.89 270.81,42.13 270.81,43.65 v2(267,47.46) ; R376.2 v2(162.18,145.98) ; R558.2 v2(294.51,44.85)
  L03_SIG1 w0.127: v2(212.9,113.17) 212.9,112.86 212.43,112.38 211.96,112.38 211.29,113.06 210.83,113.06 206.76,108.98 206.76,104.59 203.53,101.36 202.67,101.36 v2(202.41,101.11)
  L08_SIG2 w0.127: v2(267,47.46) 267,46.95 259.18,39.13 259.18,39.08 255.78,35.68 255.78,34.28 251.87,30.37 250.68,30.37 249.68,29.36 241.4,29.36 240.33,28.3 236.52,28.3 234.37,30.45 234.37,30.78 234.37,31.96 231.3,35.03 228.6,35.03 224.42,39.21 224.42,64.87 225.88,66.33 225.88,68.42 223.57,70.73 223.57,77.82 226.35,80.6 226.35,86 225.54,86.82 225.54,87.29 225.09,87.74 223.18,87.74 222.69,88.22 221.8,88.22 221.79,88.23 219.41,88.23 219.4,88.22 218.45,88.22 218.44,88.23 218.39,88.23 217.55,89.06 217.55,89.07 216.06,90.56 214.93,90.56 214.17,91.32 214.17,92.39 214.5,92.72 214.5,97.42 211.07,100.85 209.3,100.85 208.6,101.55 203.75,101.55 203.45,101.26 202.56,101.26 v2(202.41,101.11) ; v2(96.92,28.74) 96.56,29.1 95.38,29.1 88.93,35.55 88.93,59.55 85.28,63.2 73.6,63.2 69.03,58.63 69.03,53.13 69.06,53.1 v2(69.09,53.1)
  BOTTOM w0.127: v2(69.09,53.1) 72.77,53.1 77.73,58.05 90.44,58.05 93.93,61.55 93.93,63.57 92.41,65.09 92.41,103.47 94.64,105.7 v2(94.64,114.52) 94.64,114.96 94.79,115.12 94.79,122.43 100,127.64 100,186.29 101.41,187.7 108.05,187.7 110.24,189.88 110.24,198.82 112.34,200.93 112.34,212.18 113.59,213.43 121.52,213.43 121.76,213.43 126.92,208.26 126.92,196.4 128.31,195.01 150.38,195.01 151.1,194.29 168.07,177.32 168.07,155.6 162.18,149.71 v2(162.18,145.98) ; v2(294.51,44.85) 294.06,44.39 290.91,44.39 283.84,51.45 272.66,51.45 268.67,47.46 v2(267,47.46) ; v2(162.18,145.98) 162.64,146.44 163.97,146.44 164.88,145.52 172.81,145.52 175.21,147.92 191.41,147.92 196.09,143.25 207.14,143.25 211.81,138.57 211.81,126.15 212.7,125.26 212.7,115.79 213.08,115.41 213.08,113.35 v2(212.9,113.17) ; v2(162.18,145.98) 161.05,147.11 v2(157.58,147.11) ; v2(162.18,145.98) R376.2
SOC_I2C2_SCL: length 116
  TOP w0.127: R369.2 v2(169.8,150.78) 166.25,154.32 R814.2 ; R324.1 v2(256.16,161.56)
  L08_SIG2 w0.127: v2(256.16,161.56) 255.28,162.44 249.16,162.44 246.88,160.15 246.88,158.17 246.33,157.62 238.71,157.62 238.2,157.11 238.2,155.92 236.98,154.7 232.77,154.7 231.93,155.54 228.02,155.54 v2(227.84,155.72)
  BOTTOM w0.127: v2(227.84,155.72) 227.4,156.16 225.38,156.16 218.71,162.83 174.7,162.83 170.79,158.92 170.79,153.99 169.8,153 v2(169.8,150.78) R707.1
SOC_I2C2_SDA: length 116.7
  TOP w0.127: R368.2 v2(168.02,150.78) 166,152.8 R815.2 ; R325.1 v2(257.94,161.56)
  L08_SIG2 w0.127: v2(257.94,161.56) 256.78,162.71 249.05,162.71 246.63,160.3 246.63,158.27 246.26,157.9 238.59,157.9 237.92,157.23 237.92,156.04 236.87,154.98 233.27,154.98 231.39,156.86 v2(227.71,156.86)
  BOTTOM w0.127: R708.1 v2(168.02,150.78) 168.02,152.16 170.51,154.65 170.51,159.22 174.45,163.16 218.78,163.16 225.07,156.86 v2(227.71,156.86)
SOC_I2C_EN: length 44.2
  TOP w0.127: v1(78.38,191.14) 78.41,191.16 78.41,192.21 U20.V17 ; U16.5 v2(77,208.27)
  L08_SIG2 w0.127: v2(77,208.27) 77.5,208.76 85.46,208.76 88.47,205.75 88.47,200.04 90.35,198.16 90.47,198.16 91.07,197.56 91.07,193.32 v2(90.17,192.42)
  BOTTOM w0.127: v2(90.17,192.42) 90.68,191.91 90.68,191.28 90.18,190.78 82.04,190.78 82.03,190.77 81.66,191.14 v1(78.38,191.14)
SOC_INT: length 204.7
  TOP w0.127: v2(173.35,169.81) 172.59,170.58 170.74,170.58 162.43,178.88 162.43,182.1 146.27,198.26 136.98,198.26 122.13,213.11 116.81,213.11 109.51,205.81 108.84,205.15 108.84,204.74 108.84,204.74 108.84,200.29 110.24,198.9 110.24,188.86 109.31,187.94 109.31,179.63 108.8,179.12 93.95,164.27 82.63,164.27 81.79,165.11 81.79,171.85 81.25,172.38 U30.10 ; U1.N3 v1(174.01,126.61)
  L03_SIG1 w0.102: 174.29,134.89 174.29,134.25 174.47,134.08 174.47,129.76 173.6,128.88 173.6,127.03 v1(174.01,126.61)
  L03_SIG1 w0.127: v2(173.35,169.81) 173.35,166.26 174.37,165.24 174.37,142.21 174.08,141.92 174.08,141.92 172.89,140.73 172.89,138.41 174.29,137 174.29,134.89
SOC_LED0: length 315.6
  TOP w0.127: v2(67.31,127.68) 66.36,127.68 65.51,128.52 65.41,128.52 64.92,129.01 R819.2
  L03_SIG1 w0.127: v2(219.46,136.79) 219.46,137.25 218.55,138.15 207.63,138.15 207.14,137.66 v2(200.74,137.66)
  L08_SIG2 w0.127: v2(192.63,184.75) 193.79,185.9 193.79,190.01 190.87,192.93 185.17,192.93 184.02,194.07 184.02,199.46 182.93,200.55 181.61,200.55 181.58,200.52 180.21,200.52 175.64,205.09 175.64,205.12 173.61,207.15 173.61,211.47 172.67,212.41 158.06,212.41 157.4,211.75 127.79,211.75 126.67,212.87 117.42,212.87 113.62,209.07 113.62,199.99 106.17,192.55 95.78,192.55 v2(94.67,193.66)
  BOTTOM w0.127: v2(94.67,193.66) 94.18,193.18 94.18,192.44 94.54,192.09 94.54,186.67 94.13,186.26 94.13,184.37 94.72,183.78 94.72,182.23 94.24,181.75 94.24,177.08 94.87,176.44 94.87,167.02 71.81,143.96 71.81,133.77 67.31,129.28 v2(67.31,127.68) ; v2(219.46,136.79) 219.46,138.19 229.19,147.93 229.19,156.83 228.18,157.85 225.25,157.85 223.8,159.29 223.8,163.27 212.2,174.87 206.58,174.87 205.36,176.09 205.36,181.42 202.03,184.75 v2(192.63,184.75) ; R428.1 201.56,136.83 v2(200.74,137.66)
SOC_LED1: length 326.5
  TOP w0.127: R818.2 v2(68.86,128.01) ; R462.1 200.02,114.06 200.32,113.77 204.25,113.77 204.6,114.11 208.41,114.11 208.74,113.78 209.63,113.78 214.55,118.71 214.55,122.93 218.57,126.94 v2(218.57,137.05)
  L08_SIG2 w0.127: v2(191.95,184.75) 191.95,185.19 193.51,186.76 193.51,189.63 190.59,192.55 185.04,192.55 183.77,193.82 183.77,199.28 182.81,200.24 180.12,200.24 173.27,207.09 173.27,211.29 172.43,212.13 158.22,212.13 157.56,211.47 127.64,211.47 126.52,212.59 117.54,212.59 113.9,208.95 113.9,199.89 106.17,192.17 95.3,192.17 v2(94.64,192.83)
  BOTTOM w0.127: v2(68.86,128.01) 69.7,128.01 72.72,131.03 72.72,144.44 95.15,166.87 95.15,176.6 94.52,177.23 94.52,181.6 95,182.08 95,183.9 94.41,184.48 94.41,186.15 94.82,186.55 94.82,192.2 94.64,192.38 v2(94.64,192.83) ; v2(191.95,184.75) 191.95,183.91 204.46,171.4 215.28,171.4 223.47,163.2 223.47,159.14 225.09,157.52 227.7,157.52 228.92,156.3 228.92,148.16 218.57,137.81 v2(218.57,137.05)
SOC_LED2: length 37.2
  TOP w0.127: U51.5 84.64,110.57 74.44,120.78 74.44,135.64 73.69,136.39 LD4.1
SOC_LED3: length 34.5
  TOP w0.127: LD2.1 77.5,119.37 85.79,111.07 U51.4
SOC_LED4: length 32
  TOP w0.127: LD5.1 80.8,117.59 86.81,111.57 U51.3
SOC_LRESETNMIENZ: length 139.1
  TOP w0.127: v1(169.21,132.42) 169.61,132.02 U1.V1 ; U24.20 v2(89.17,185.38)
  L08_SIG2 w0.102: v1(169.21,132.42) 168.54,133.09 168.54,134.89
  L08_SIG2 w0.127: v2(89.17,185.38) 89.66,185.88 89.66,186.83 89.84,187.01 103.17,187.01 107.57,191.4 154.06,191.4 162.23,183.23 162.23,155.99 162.61,155.61 162.61,152.88 162.42,152.69 162.42,150.22 162.53,150.1 162.53,148.15 162.2,147.82 162.2,147.03 162.73,146.51 163.87,146.51 164.22,146.15 164.22,141.21 166.26,139.18 166.26,137.26 166.55,136.97 166.6,136.97 168.54,135.03 168.54,134.89
SOC_LRESETZ: length 141
  TOP w0.127: U1.V2 169.21,128.21 v1(169.21,129.88) ; v2(89.17,186.27) 88.67,185.77 U24.21
  L08_SIG2 w0.102: 168.82,134.89 168.82,133.45 169.6,132.68 169.6,131 169.21,130.62 v1(169.21,129.88)
  L08_SIG2 w0.127: v2(89.17,186.27) 89.17,186.96 89.5,187.29 102.95,187.29 107.34,191.68 154.18,191.68 162.53,183.32 162.53,156.02 162.85,155.71 162.85,152.78 162.74,152.67 162.74,150.26 163.02,149.98 163.02,148.81 162.78,148.57 162.78,148.05 162.69,147.96 162.69,147.21 163.07,146.83 163.95,146.83 164.5,146.27 164.5,142.5 165.86,141.14 165.86,140.22 167.26,138.83 167.26,136.87 168.82,135.31 168.82,134.89
SOC_MCASP0ACLKR: length 141.7
  L03_SIG1 w0.127: v2(194.97,124.53) 195.21,124.53 195.23,124.55 196.89,124.55 198.51,122.93 201.05,122.93 201.15,123.03 203.12,123.03 203.91,122.24 208.91,122.24 209.32,122.65 215.11,122.65 216.22,121.54 247.35,121.54 257.32,111.57 276.78,111.57 286.07,102.29 286.07,91.44 286.05,91.42 286.05,91.12 288.29,88.89 288.29,81.71 JP1.59
  BOTTOM w0.127: v2(194.97,124.53) 194.36,123.92 194.36,123.78 194.06,123.48 193.39,123.48 192.9,123.97 R470.1
SOC_MCASP0ACLKX: length 174.4
  TOP w0.127: U115.4 296.73,54.19 297.22,53.69 v2(297.54,53.69) ; v2(193.45,117.08) 193.52,117.01 193.07,117.01 192.86,116.8 192.86,116.29 R452.1
  L03_SIG1 w0.127: v2(193.45,117.08) 193.88,116.65 196.38,116.65 198.97,114.06 202.45,114.06 204.09,115.7 243.76,115.7 254.79,104.66 255.55,104.66 265.77,94.45 274.51,94.45 276.81,92.15 276.81,76.4 276.81,75.79 278.41,74.19 278.41,71.11 286.26,63.26 289.63,63.26 293.89,59.01 293.89,56.98 294.89,55.97 294.89,55.06 294.03,54.19 294.03,53.3 294.89,52.44 294.89,51.97 294.89,51.97 294.89,51.65 294.89,51.65 294.89,48.93 298.01,45.82 298.01,42.85 298.77,42.08 JP1.81
  BOTTOM w0.127: JP1.81 297.94,44.12 297.94,53.29 v2(297.54,53.69)
SOC_MCASP0AHCLKR: length 141.7
  TOP w0.127: R473.1 v2(193.98,125.49)
  L03_SIG1 w0.127: JP1.54 301.24,76.37 299.11,76.37 290.09,85.38 290.09,93.43 289.81,93.71 289.81,96.33 290.31,96.83 290.31,100.44 288.52,102.23 288.52,103.44 278.87,113.1 258.22,113.1 247.68,123.64 217.2,123.64 216.78,124.05 205.87,124.05 205.6,124.32 202.38,124.32 202.26,124.45 199.1,124.45 197.4,126.15 195.53,126.15 195.23,126.45 194.56,126.45 193.98,125.87 v2(193.98,125.49)
SOC_MCASP0AHCLKX: length 167.4
  TOP w0.127: v2(296.88,62.68) 296.55,63.01 U139.2 ; v2(201.9,120.61) 201.9,120.59 202.16,120.84 v2(202.16,121.96)
  L03_SIG1 w0.127: v2(201.9,120.61) 202.06,120.46 214.4,120.46 215.6,119.27 221.67,119.27 222.32,118.61 222.59,118.34 247.35,118.34 256.24,109.45 275.81,109.45 280.85,104.42 280.85,98.63 282.28,97.21 282.5,96.98 282.5,95.09 282.17,94.76 282.17,81.16 294.89,68.44 294.89,64.66 v2(296.88,62.68)
  L08_SIG2 w0.127: v2(195.25,130.84) 195.25,130.88 196.55,129.58 196.55,128.72 198.78,126.48 200.03,126.48 201.04,127.49 201.71,127.49 202.08,127.12 202.08,122.04 v2(202.16,121.96)
  BOTTOM w0.127: v2(195.25,130.84) 194.42,130.01 192.85,130.01 R408.1 ; R458.1 193.31,120.92 193.76,121.38 194.44,121.38 194.77,121.71 195.4,121.71 195.76,121.35 198.3,121.35 198.51,121.55 199.57,121.55 200.37,120.75 201.74,120.75 201.9,120.59 v2(201.9,120.61)
SOC_MCASP0AMUTE: length 115.5
  L03_SIG1 w0.127: JP1.30 301.45,107.06 297.2,107.06 285.57,118.68 260.86,118.68 250.52,129.02 223.24,129.02 223.23,129.03 223.19,129.03 221.57,130.66 201.64,130.66 200.96,131.33 v2(199.77,131.33)
  BOTTOM w0.127: v2(199.77,131.33) 199.28,131.82 198.47,131.82 197.98,131.33 R444.1
SOC_MCASP0AXR0: length 157.3
  TOP w0.127: R482.1 v2(199.01,125.24) ; U115.6 297.04,55.19 v2(297.54,54.69)
  L03_SIG1 w0.127: JP1.53 290.47,87.14 290.47,93.59 290.19,93.87 290.19,96.08 290.69,96.57 290.69,100.6 288.9,102.39 288.9,103.6 279.02,113.48 258.38,113.48 247.84,124.02 217.58,124.02 217.16,124.43 206.03,124.43 205.83,124.63 202.62,124.63 202.28,124.97 200.15,124.97 199.96,124.78 199.47,124.78 v2(199.01,125.24)
  L08_SIG2 w0.127: JP1.53 298.32,75.99 298.32,55.48 v2(297.54,54.69)
SOC_MCASP0AXR1: length 155.9
  TOP w0.127: U115.8 297.04,56.19 v2(297.54,55.69) ; R454.1 v2(193.95,122.44)
  L03_SIG1 w0.127: JP1.69 294.39,62.91 294.39,68.41 281.69,81.11 281.69,94.83 282.12,95.26 282.12,96.83 280.47,98.48 280.47,104.03 275.49,109.01 256.06,109.01 247.11,117.96 222.34,117.96 221.41,118.89 215.21,118.89 214.66,119.45 201.7,119.45 199.99,121.16 198.13,121.16 196.9,122.39 194.01,122.39 v2(193.95,122.44)
  BOTTOM w0.127: JP1.69 298.89,57.32 298.4,56.83 298.4,56.56 v2(297.54,55.69)
SOC_MCASP0AXR2: length 156.4
  TOP w0.127: R451.1 v2(199.01,123.71) ; v2(296.65,56.69) 296.17,56.69 296.17,56.69 U115.9
  L03_SIG1 w0.127: v2(199.01,123.71) 199.12,123.71 199.58,123.26 200.84,123.26 200.99,123.41 203.3,123.41 204.06,122.65 208.63,122.65 209.01,123.03 215.37,123.03 215.77,122.62 246.99,122.62 257.58,112.03 277.11,112.03 286.45,102.69 286.45,91.32 288.77,88.99 288.77,81.88 299.34,71.31 301.23,71.31 JP1.60
  BOTTOM w0.127: JP1.60 301.24,68.75 298.96,68.75 297.94,67.73 297.94,60.47 296.65,59.17 v2(296.65,56.69)
SOC_MCASP0AXR3: length 154.9
  TOP w0.127: U115.10 297.04,57.19 v2(297.54,56.69) ; R447.1 v2(193.95,120.92)
  L03_SIG1 w0.127: JP1.76 301.05,51.17 299.01,51.17 298.15,52.03 298.15,56.53 297.98,56.69 v2(297.54,56.69) 297.54,58.16 293.24,62.46 293.24,67.71 278.36,82.59 278.36,92.83 276.25,94.93 276.25,95.48 273.5,98.24 270.21,98.24 260.38,108.07 255.8,108.07 246.71,117.16 221.81,117.16 221.04,117.92 214.12,117.92 213.33,118.71 200.62,118.71 199.2,120.13 198.77,120.13 197.23,121.67 194.7,121.67 v2(193.95,120.92)
SOC_MCASP0AXR4: length 134.4
  L03_SIG1 w0.127: v2(199.77,123.71) 203.56,123.71 203.86,123.41 215.89,123.41 216.39,122.9 247.27,122.9 257.86,112.31 278.51,112.31 286.69,104.12 286.69,91.63 289.23,89.09 289.23,83.31 JP1.57
  BOTTOM w0.127: v2(199.77,123.71) 199.31,124.17 198.82,124.17 198.36,123.71 R480.1
SOC_MCASP0AXR5: length 124.4
  L03_SIG1 w0.127: v2(199.84,127.02) 200.84,127.02 201.31,126.56 201.87,126.56 202.06,126.75 204.71,126.75 204.97,127 220.69,127 221.82,125.87 249.08,125.87 259.59,115.37 281.03,115.37 292.57,103.83 292.57,97.97 296.93,93.61 296.93,90.85 JP1.45
  BOTTOM w0.127: v2(199.84,127.02) 199.84,127.01 199.84,126.83 199.28,126.27 198.47,126.27 197.98,126.76 R476.1
SOC_MCASP0AXR6: length 147.1
  L03_SIG1 w0.127: JP1.77 298.91,47.16 295.83,50.24 295.83,59.18 292.48,62.54 292.48,67.2 277.77,81.9 277.77,92.57 275.69,94.66 275.69,95.25 273.34,97.6 269.19,97.6 259.28,107.51 255.49,107.51 246.39,116.6 209.07,116.6 208.84,116.83 200.34,116.83 199.79,117.38 198.72,117.38 198.27,117.82 v2(198.27,118.25)
  BOTTOM w0.127: R472.1 197.91,118.57 198.27,118.2 v2(198.27,118.25)
SOC_MCASP0AXR7: length 133.7
  L03_SIG1 w0.127: v2(199.77,125.24) 202.35,125.24 202.72,124.87 205.96,124.87 206.13,124.7 208.87,124.7 209.4,125.22 219.94,125.22 220.47,124.7 220.83,124.34 220.89,124.34 220.93,124.3 247.95,124.3 258.5,113.76 279.12,113.76 289.28,103.6 289.28,102.4 290.93,100.75 290.93,96.57 291.45,96.05 292.74,94.77 292.74,85.51 299.29,78.96 301.29,78.96 JP1.52
  BOTTOM w0.127: v2(199.77,125.24) 199.31,125.69 198.82,125.69 198.36,125.24 R469.1
SOC_MCASP0AXR8: length 147.8
  TOP w0.127: R441.1 v2(203.81,116.07)
  L03_SIG1 w0.127: JP1.82 301.25,43.35 299.34,43.35 298.5,44.19 298.5,45.86 295.27,49.09 295.27,58.16 291.64,61.79 291.64,64.35 289.94,66.05 287.27,66.05 277.19,76.14 277.19,92.31 274.66,94.83 269.7,94.83 257.99,106.54 254.63,106.54 245.1,116.08 204.22,116.08 204.2,116.09 203.83,116.09 v2(203.81,116.07)
SOC_MCASP0AXR9: length 150.9
  TOP w0.127: R437.1 v2(203.86,114.52)
  L03_SIG1 w0.127: v2(203.86,114.52) 207.46,114.52 208.26,115.32 243.6,115.32 254.63,104.28 255.4,104.28 265.61,94.07 273.63,94.07 274.02,93.69 274.02,93.4 274.28,93.13 275.08,93.13 276.38,91.84 276.38,75.68 278.02,74.03 278.02,67.43 282.57,62.88 289.48,62.88 292.35,60 292.35,56.96 293.17,56.15 293.17,54.62 293.55,54.24 293.55,52.75 294.41,51.88 294.41,48.86 297.62,45.65 297.62,40.34 298.42,39.54 JP1.83
SOC_MCASP0AXR10: length 22.1
  TOP w0.127: U1.E11 v1(179.61,120.21) ; v2(190.12,118.35) 190.27,118.2 R820.2 191.57,118.2 192.16,117.6 194.32,117.6 194.68,117.24 194.68,116.5 196.58,114.61 R462.2
  L03_SIG1 w0.102: v1(179.61,120.21) 180.49,120.21 180.87,119.83 181.46,119.83 181.61,119.67 181.61,119.14 ; 185.45,118.91 186.74,117.62 189.1,117.62
  L03_SIG1 w0.127: v2(190.12,118.35) 189.38,117.62 189.1,117.62 ; 181.61,119.14 181.74,119.01 182.4,119.01 182.78,119.39 184.96,119.39 185.45,118.91
SOC_MCASP0AXR10_R: length 157
  TOP w0.127: R820.1 192.84,118.16 193.84,118.16 v2(194.18,118.51)
  L03_SIG1 w0.127: v2(194.18,118.51) 194.82,117.87 196.85,117.87 197.62,117.1 199.63,117.1 200.18,116.55 208.61,116.55 208.84,116.32 245.26,116.32 254.66,106.92 258.9,106.92 269.77,96.05 272.75,96.05 273.69,95.11 274.78,95.11 277.5,92.4 277.5,76.85 285.75,68.59 289.43,68.59 292.1,65.93 292.1,62.58 295.55,59.12 295.55,49.7 299.31,45.94 301.29,45.94 JP1.78
SOC_MCASP0AXR12: length 141.6
  L03_SIG1 w0.127: JP1.71 298.86,55.9 298.86,57.6 294,62.45 294,68.09 280.85,81.24 280.85,90.49 280.71,90.63 280.71,93.14 280.86,93.3 280.86,93.92 274.91,99.86 270.08,99.86 261.32,108.63 256.04,108.63 246.98,117.69 222.15,117.69 221.26,118.58 214.99,118.58 214.38,119.19 201.24,119.19 v2(199.77,120.66)
  BOTTOM w0.127: R459.1 198.36,120.66 198.82,121.12 199.31,121.12 v2(199.77,120.66)
SOC_MCASP0AXR13: length 140.2
  L03_SIG1 w0.127: JP1.63 284.76,80.16 284.76,91.15 285.39,91.79 285.39,93.01 285.4,93.02 285.4,101.79 285.39,101.8 285.39,101.96 276.77,110.58 256.7,110.58 248.07,119.2 223.06,119.2 221.98,120.28 216.43,120.28 215.37,121.35 203.62,121.35 202.55,122.42 201.78,122.42 201.45,122.09 199.87,122.09 v2(199.78,122.18)
  BOTTOM w0.127: R481.1 198.36,122.19 198.82,122.65 199.31,122.65 199.75,122.21 199.75,122.18 v2(199.78,122.18)
SOC_MCASP0AXR14: length 142.3
  TOP w0.127: R460.1 198.98,122.19 v2(199.03,122.14)
  L03_SIG1 w0.127: JP1.65 295.74,66.64 295.74,68.64 282.83,81.55 282.83,91.3 283.63,92.1 283.63,92.12 283.89,92.38 283.91,92.38 284.43,92.9 284.43,95.75 284.56,95.87 284.56,99.23 283.57,100.22 283.57,102.63 275.97,110.23 256.54,110.23 247.8,118.96 222.96,118.96 222.01,119.92 216.14,119.92 214.96,121.1 203.23,121.1 202.92,121.4 200.63,121.4 200.32,121.72 199.48,121.72 199.03,122.16 v2(199.03,122.14)
SOC_MCASP0AXR15: length 145.2
  TOP w0.127: R477.1 v2(199.01,120.66)
  L03_SIG1 w0.127: JP1.72 301.26,53.53 299.26,53.53 298.55,54.24 298.55,57.49 293.62,62.42 293.62,67.83 279.78,81.68 279.78,93.83 274.2,99.41 269.67,99.41 260.73,108.35 255.92,108.35 246.83,117.44 222,117.44 221.16,118.28 214.71,118.28 214.03,118.95 200.72,118.95 v2(199.01,120.66)
SOC_MCASP0FSR: length 148.1
  TOP w0.127: R468.1 v2(193.9,123.97)
  L03_SIG1 w0.127: v2(193.9,123.97) 195.19,123.97 195.39,124.17 196.43,124.17 197.97,122.63 199.97,122.63 200.11,122.49 201.22,122.49 201.37,122.65 201.66,122.65 201.68,122.66 202.65,122.66 202.67,122.65 202.86,122.65 203,122.51 203.01,122.51 203.66,121.86 209.07,121.86 209.47,122.27 214.93,122.27 216.6,120.6 222.01,120.6 223.16,119.45 248.56,119.45 257.18,110.82 276.9,110.82 285.69,102.03 285.69,91.59 285.01,90.92 285.01,80.94 299.79,66.16 301.3,66.16 JP1.64
SOC_MCASP0FSX: length 166.5
  TOP w0.127: JP1.66 301.34,61.23 299.21,61.23 298.3,60.31 298.3,54.5 297.99,54.19 297.31,54.19 296.81,54.69 U115.5
  L03_SIG1 w0.127: JP1.66 301.26,61.15 299.26,61.15 295.27,65.14 295.27,68.59 282.55,81.32 282.55,94.59 282.88,94.92 282.88,95.36 284.28,96.75 284.28,99.09 283.13,100.23 283.13,102.67 276.19,109.61 275.97,109.83 256.4,109.83 247.51,118.72 222.75,118.72 221.82,119.65 215.87,119.65 214.68,120.84 202.79,120.84 202.54,121.1 200.48,121.1 200.14,121.44 198.29,121.44 196.65,123.08 v2(194.84,123.08)
  BOTTOM w0.127: R448.1 193.29,122.44 193.52,122.67 193.54,122.67 193.94,123.08 v2(194.84,123.08)
SOC_MCASP1ACLKR: length 119.5
  TOP w0.127: R398.1 192.9,131.59 193.2,131.89 193.29,131.97 193.51,131.97 193.75,132.21 195.06,132.21 v2(195.17,132.09)
  L03_SIG1 w0.127: JP1.33 285.1,117.92 261.08,117.92 260.7,118.3 250.59,128.41 250.57,128.41 250.34,128.64 223.03,128.64 221.93,129.75 202.01,129.75 200.93,130.83 200.59,130.83 200.59,130.82 198.7,130.82 197.43,132.09 v2(195.17,132.09)
SOC_MCASP1ACLKX: length 123.2
  L03_SIG1 w0.127: JP1.34 301.32,101.85 299.48,101.85 298.22,103.11 298.22,104.09 284.78,117.54 260.92,117.54 260.54,117.92 250.43,128.03 250.41,128.03 250.18,128.26 222.87,128.26 221.77,129.36 201.86,129.36 200.8,130.42 198.57,130.42 197.4,131.59 194.16,131.59 194.16,131.59 194.04,131.59 v2(193.89,131.44)
  BOTTOM w0.127: R405.1 193.55,131.59 193.55,131.59 193.74,131.59 v2(193.89,131.44)
SOC_MCASP1AHCLKR: length 129.6
  L03_SIG1 w0.127: v2(193.98,128.69) 195,128.69 195.06,128.75 197.52,128.75 198.63,127.64 202.09,127.64 202.61,127.13 204.19,127.13 204.52,127.46 221.1,127.46 222.3,126.25 249.36,126.25 259.86,115.75 281.7,115.75 293.72,103.73 293.72,97.63 298.78,92.57 298.78,92.39 299.48,91.69 301.32,91.69 JP1.42
  BOTTOM w0.127: R402.1 193.83,128.54 v2(193.98,128.69)
SOC_MCASP1AMUTE: length 22
  TOP w0.127: U1.A5 183.39,125.41 184.66,126.68 186.85,126.68 187.41,127.25 187.41,127.67 188.09,128.35 189.44,128.35 190.25,129.16 190.96,129.16 R817.2 191.54,128.62 192.03,129.1 192.03,129.1 192.21,129.29 192.21,129.29 192.25,129.33 193.9,129.33 194.77,130.19 194.77,131.09 195.03,131.36 195.41,131.36 195.9,130.88 200.09,130.88 200.87,131.66 R823.2
SOC_MCASP1AMUTE_R: length 106.5
  TOP w0.127: R823.1 v2(203.5,131.66)
  L03_SIG1 w0.127: JP1.27 299.84,110.53 298.27,110.53 289.37,119.43 261.23,119.43 250.9,129.76 250.85,129.76 250.82,129.78 223.67,129.78 221.79,131.66 v2(203.5,131.66)
SOC_MCASP1AXR0: length 112.3
  TOP w0.127: R439.1 198.58,131.76 v2(199.01,131.33)
  L03_SIG1 w0.127: v2(199.01,131.33) 199.54,131.87 200.94,131.87 201.85,130.95 221.61,130.95 223.29,129.28 250.62,129.28 260.97,118.93 286.32,118.93 297.12,108.12 JP1.29
SOC_MCASP1AXR1: length 119.5
  TOP w0.127: R434.1 v2(199.01,129.81)
  L03_SIG1 w0.127: JP1.36 301.45,99.44 299.06,99.44 297.56,100.94 297.56,103.82 284.46,116.92 260.64,116.92 249.92,127.64 222.62,127.64 221.51,128.74 202.55,128.74 202.37,128.56 200.77,128.56 200,129.33 199.48,129.33 v2(199.01,129.81)
SOC_MCASP1AXR2: length 121.5
  TOP w0.127: R430.1 202.38,125.95 v2(203.2,125.95)
  L03_SIG1 w0.127: JP1.47 298.14,85.26 296.29,87.11 296.29,92.95 291.99,97.26 291.99,102.4 279.59,114.8 258.92,114.8 248.37,125.34 221.27,125.34 220.13,126.48 206.45,126.48 206.22,126.26 203.51,126.26 v2(203.2,125.95)
SOC_MCASP1AXR3: length 123.6
  TOP w0.127: R425.1 198.56,128.28 198.82,128.54 v2(199.26,128.54)
  L03_SIG1 w0.127: JP1.40 301.45,94.36 299.53,94.36 296.52,97.37 296.52,104.04 284.19,116.37 260.34,116.37 249.56,127.15 222.42,127.15 221.31,128.26 204.26,128.26 203.82,127.82 202.8,127.82 202.35,128.26 200.7,128.26 200.43,128.54 v2(199.26,128.54)
SOC_MCASP1AXR4: length 115.5
  TOP w0.127: R422.1 202.97,128.01 v2(203.24,128.28)
  L03_SIG1 w0.127: v2(203.24,128.28) 203.47,128.5 221.41,128.5 222.52,127.4 249.73,127.4 260.48,116.65 284.33,116.65 295.32,105.66 295.33,105.66 297.13,103.86 297.13,97.22 298.91,95.44 299.96,95.44 JP1.39
SOC_MCASP1AXR5: length 139.4
  TOP w0.127: R419.1 v2(203.81,117.59)
  L03_SIG1 w0.127: JP1.75 298.91,49.7 296.15,52.46 296.15,59.21 292.86,62.5 292.86,67.45 278.05,82.26 278.05,92.7 275.97,94.78 275.97,95.37 273.38,97.96 269.77,97.96 259.94,107.79 255.63,107.79 246.53,116.88 221.58,116.88 220.86,117.6 212.76,117.6 211.91,118.46 204.67,118.46 v2(203.81,117.59)
SOC_MCASP1AXR6: length 127.9
  TOP w0.127: R416.1 198.89,126.76 199.06,126.93 v2(199.06,127.03)
  L03_SIG1 w0.127: v2(199.06,127.03) 199.52,126.56 200.94,126.56 201.22,126.28 201.94,126.28 202.16,126.51 205.99,126.51 206.02,126.53 206.25,126.76 220.24,126.76 221.41,125.59 248.97,125.59 259.43,115.13 280.7,115.13 292.27,103.56 292.27,97.54 296.57,93.23 296.57,89.7 299.53,86.74 301.45,86.74 JP1.46
SOC_MCASP1AXR7: length 142.7
  L03_SIG1 w0.127: JP1.58 301.33,73.75 299.82,73.75 289.71,83.86 289.71,93.27 289.43,93.55 289.43,96.56 289.69,96.81 289.69,98.64 288.09,100.24 288.09,103.29 278.74,112.64 257.87,112.64 247.37,123.14 247.36,123.14 247.24,123.26 216.6,123.26 216.21,123.65 204.09,123.65 203.72,124.02 200.11,124.02 199.96,124.17 198.84,124.17 197.27,125.74 195.35,125.74 195.12,125.98 v2(194.89,125.98)
  BOTTOM w0.127: v2(194.89,125.98) 193.39,125.98 192.9,125.49 R414.1
SOC_MCASP1AXR8: length 116.4
  L03_SIG1 w0.127: JP1.35 298.39,100.5 297.84,101.06 297.84,103.94 284.62,117.16 260.77,117.16 260.38,117.54 250.28,127.65 250.26,127.65 250.03,127.88 222.72,127.88 221.61,128.98 201.69,128.98 200.86,129.81 v2(199.77,129.81)
  BOTTOM w0.127: R412.1 198.36,129.81 198.54,129.99 198.54,130 198.81,130.28 198.83,130.28 198.9,130.34 199.24,130.34 v2(199.77,129.81)
SOC_MCASP1AXR9: length 135.6
  TOP w0.127: R410.1 v2(193.93,127.01)
  L03_SIG1 w0.127: v2(193.93,127.01) 195.1,127.01 195.3,127.22 197.05,127.22 198.09,126.18 198.82,126.18 199.21,125.8 200.63,125.8 200.68,125.74 200.91,125.52 202.41,125.52 202.59,125.34 202.82,125.11 206.31,125.11 206.43,125 208.66,125 209.26,125.59 219.92,125.59 220.71,124.8 220.93,124.58 221.25,124.58 248.06,124.58 258.6,114.04 279.27,114.04 289.64,103.67 289.64,102.52 291.17,100.98 291.17,96.67 291.55,96.29 294.18,93.66 294.18,84.91 298.91,80.18 JP1.51
SOC_MCASP1FSR: length 127.4
  TOP w0.127: R394.1 192.83,130.14 193.23,130.14 193.56,130.47 v2(194.01,130.47)
  L03_SIG1 w0.127: JP1.41 296.11,96.75 296.11,104.02 284,116.13 260.21,116.13 249.71,126.63 222.5,126.63 221.3,127.84 204.36,127.84 204.03,127.51 202.77,127.51 202.25,128.02 198.79,128.02 196.47,130.34 194.13,130.34 v2(194.01,130.47)
SOC_MCASP1FSX: length 120.4
  L03_SIG1 w0.127: v2(195.2,133.24) 197.03,133.24 198.09,132.17 201.09,132.17 202.07,131.2 221.8,131.2 223.47,129.53 250.72,129.53 250.75,129.5 250.79,129.5 261.1,119.19 261.11,119.19 261.14,119.17 287.2,119.17 296.77,109.6 301.45,109.6 JP1.28
  BOTTOM w0.127: R404.1 192.9,133.11 193.54,133.75 194.69,133.75 v2(195.2,133.24)
SOC_MCASP2ACLKR: length 115.5
  TOP w0.127: v2(195.2,134.63) 194.71,135.13 193.39,135.13 192.9,134.63 R401.1
  L03_SIG1 w0.127: JP1.23 298.33,115.74 294.02,120.06 261.59,120.06 251.49,130.16 251.49,130.19 251.28,130.39 251.13,130.39 251.1,130.42 224.08,130.42 221.92,132.58 221.91,132.58 221.86,132.63 204.7,132.63 204.01,133.31 202.44,133.31 201.76,134 199.82,134 199.62,133.8 198.81,133.8 197.97,134.63 v2(195.2,134.63)
SOC_MCASP2ACLKX: length 31.8
  TOP w0.127: U64.13 198.53,154.05 v2(199.11,154.62) ; R413.1 193.48,133.11 193.61,133.24 v2(194.06,133.24)
  L08_SIG2 w0.127: v2(199.11,154.62) 199.56,154.62 199.68,154.5 199.68,153.26 195.06,148.64 195.06,145.91 192.41,143.25 192.41,143.24 192.33,143.16 192.33,138.27 194.11,136.49 194.11,135.75 194.54,135.32 194.54,133.72 v2(194.06,133.24)
  BOTTOM w0.127: U136.4 198.52,154.04 v2(199.11,154.62)
SOC_MCASP2AHCLKR: length 92.9
  TOP w0.127: U56.3 v2(197.36,95.52) ; R407.1 198.4,137.17 199.59,137.17 v2(199.75,137.33)
  L03_SIG1 w0.127: v2(216.53,102.94) 212.47,98.87 212.47,98.09 212.47,97.77 211.36,96.66 208.13,96.66 206.92,95.46 205.03,95.46 204.96,95.52 v2(197.36,95.52) ; v2(216.97,136.74) 216.92,136.79 208.11,136.79 207.75,137.15 199.92,137.15 v2(199.75,137.33)
  BOTTOM w0.127: v2(216.53,102.94) 210.57,102.94 210.24,103.27 208.53,103.27 207.44,104.36 207.44,108.4 208.7,109.65 212.23,109.65 216.2,113.62 216.2,118.59 218.34,120.72 218.34,135.37 v2(216.97,136.74)
SOC_MCASP2AHCLKX: length 135.9
  L03_SIG1 w0.127: v2(194.79,127.5) 195.04,127.5 195.14,127.6 197.21,127.6 198.24,126.57 198.98,126.57 199.37,126.18 200.78,126.18 201.06,125.9 202.56,125.9 202.56,125.9 202.97,125.49 205.99,125.49 206.6,126.1 219.95,126.1 221.09,124.96 248.22,124.96 258.76,114.42 279.43,114.42 291.6,102.24 291.6,96.78 291.71,96.67 295.83,92.55 295.83,86.32 298.12,84.04 301.29,84.04 JP1.48
  BOTTOM w0.127: R417.1 193.24,127.01 193.73,127.5 v2(194.79,127.5)
SOC_MCASP2AMUTE: length 23.5
  TOP w0.127: v1(182.01,129.88) 182.01,128.21 U1.C2
  BOTTOM w0.102: v1(182.01,129.88) 183.28,131.16 186.05,131.16 186.36,130.85 188.57,130.85 189.1,131.38
  BOTTOM w0.127: 189.1,131.38 189.64,131.92 189.64,132.83 189.92,133.11 189.92,133.98 190.12,134.18 190.12,135.14 190.5,135.52 190.5,136.26 190.89,136.65 193.92,136.65 193.93,136.67 195.17,136.67 195.93,135.9 R822.2 R393.2
SOC_MCASP2AMUTE_R: length 109.6
  L03_SIG1 w0.127: JP1.21 298.26,118.28 295.86,120.69 262.08,120.69 251.73,131.04 251.4,131.04 251.38,131.05 224.46,131.05 221.27,134.24 204.81,134.24 203.61,135.45 202.56,135.45 201.88,136.13 199.24,136.13 v2(199.01,135.9)
  BOTTOM w0.127: R822.1 v2(199.01,135.9)
SOC_MCASP2AXR0: length 29.5
  TOP w0.127: U1.D3 v1(180.41,127.41)
  BOTTOM w0.102: 180.72,128.09 180.41,127.78 v1(180.41,127.41) ; 182.85,129.1 184.71,130.95 185.97,130.95 186.28,130.65 188.77,130.65 189.1,130.98
  BOTTOM w0.127: 182.85,129.1 181.41,129.1 180.72,128.41 180.72,128.09 ; R428.2 200.26,136.13 199.39,135.25 196.91,135.25 196.58,134.93 R821.2 195.93,134.38 195.71,134.61 195.71,135.65 195,136.36 190.96,136.36 190.75,136.16 190.75,135.42 190.45,135.12 190.45,135.09 190.42,135.07 190.42,134.09 190.2,133.87 190.2,132.99 189.94,132.74 189.94,132.4 189.94,132.4 189.94,131.82 189.1,130.98
SOC_MCASP2AXR0_R: length 112.6
  L03_SIG1 w0.127: v2(199.01,134.38) 200.49,134.38 200.49,134.38 200.87,134.38 201.2,134.71 203.84,134.71 204.77,133.77 206.81,133.77 207.57,133.01 221.69,133.01 221.72,133.03 222.02,133.03 222.07,132.98 222.07,132.96 222.1,132.96 224.26,130.8 251.28,130.8 251.31,130.77 251.46,130.77 251.87,130.37 251.87,130.34 261.77,120.44 295.72,120.44 299.05,117.11 301.35,117.11 301.62,117.39 301.62,117.4 JP1.22
  BOTTOM w0.127: R821.1 v2(199.01,134.38)
