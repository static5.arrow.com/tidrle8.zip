# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Nets (continued)
N22388802: TP94.1(TP) U20.V6(PF1/EN0LED2/M0PWM1/SSI3XDAT0/TR)
N22388818: TP95.1(TP) U20.U6(PF0/EN0LED0/M0PWM0/SSI3XDAT1/TR)
N22388827: TP93.1(TP) U20.W6(PF2/EN0MDC/M0PWM2/SSI3FSS/TRD0)
N22391170: R808.2 SW14.1
N22515669: R503.2 U75.1(EOH)
N22519288: R742.2 U69.2(1DIR) U69.3(2DIR)
N22525689: R806.1 U84.2(A)
N22774183: TP175.1(TP) U32.L5(GPIO0)
N22774186: TP107.1(TP) U32.F6(GPIO1)
N22774189: TP111.1(TP) U32.G6(GPIO5)
N22774190: TP108.1(TP) U32.H7(GPIO4)
N22774191: TP88.1(TP) U32.B7(GPIO3)
N22774198: TP117.1(TP) U32.K5(GPIO8)
N22816314: Q15.1(G) R819.1
N22816317: LD3.1 Q15.3(D)
N22816577: LD1.1 Q14.3(D)
N22816587: Q14.1(G) R818.1
N22822538: C742.1 R853.1
N22894279: R827.1 U115.7(A5)
N22896034: R876.2 U115.3(A1)
N22896196: R500.1 U69.4(1A1)
N23280297: R832.2 U122.5(DIR)
N23290716: R747.1 U76.10(DIR1)
N23290763: R834.2 U76.1(DIR2)
N23291275: R835.1 U124.10(DIR1)
N23291293: R836.2 U124.1(DIR2)
N23455572: R839.2 U126.3(2DIR)
N23499910: R840.2 U125.3(2DIR)
N23499916: R841.2 R842.1 U125.2(1DIR)
N23506369: R843.1 U128.2(1DIR) U128.3(2DIR)
N23623251: C743.2 L9.1 U116.9(SW1) U116.10(SW2) U116.11(SW3)
N23623286: C743.1 U116.12(VBST)
N23623990: C741.1 U116.2(VREG5)
N23625135: R853.2 U116.3(SS)
N23636920: R838.1 U126.2(1DIR)
N23802356: R864.2 U132.7(A5) U132.10(A8)
N23802386: R866.2 U132.21(B1)
N23802411: R865.1 U132.2(DIR)
N23851798: R352.1 U1.L22(EMU01)
N23851802: R350.1 U1.M22(EMU00)
N23881985: R697.1 U37.1(S)
N23882833: R868.1 U134.15(E\)
N23883268: R869.2 U59.5(DIR)
N23883344: R867.1 U133.15(E\)
N23992168: R873.1 U136.7(2A2)
N23992275: R787.2 SW15.1
N23992339: R874.2 U137.5(DIR)
N23995153: R812.1 U64.7(2A2)
N23995260: R748.2 SW11.1
N23995326: R870.2 U135.5(DIR)
N24555288: R875.1 U1.AB24(GPMC_BEN1/GPIO0_21)
N24769033: R880.1 U17.N19(USB0_VBUS)
N25011059: C793.1 U10.4(BYPASS)
N25715331: R882.1 U138.6(C)
N25716335: J46.1 R633.1
N25806665: J45.1 R886.1
N25806674: J45.3 R887.1
N26130196: C805.2 L10.1 U141.9(SW1) U141.10(SW2) U141.11(SW3)
N26130204: C805.1 U141.12(VBST)
N26130308: C810.1 U141.2(VREG5)
N26134731: R897.1 U141.3(SS)
N26134738: C811.1 R897.2
N26188507: TP68.1(TP) U20.M2(PC4/C1-/EPI0S7/T7CCP0/U7RX)
N26212205: R903.1 U142.8(A7) U142.9(A8)
N26212363: R902.1 U142.12(B8) U142.13(B7)
N26217961: R681.2 U29.M6(CLK)
N26217993: R687.2 U29.M5(CMD)
N26218848: R267.2 R268.1 R676.2 R678.1
N26218884: R678.2 U29.K5(RST_N)
N27235884: C288.2 U74.16(DCD_ECI/VPP)
N27236702: R504.2 U74.9(R\S\T\)
N27263094: C394.1 U13.6(C2-)
N27263096: C394.2 U13.5(C2+)
N27263102: C391.1 U13.2(C1+)
N27263104: C391.2 U13.4(C1-)
N27263131: C41.2 U13.3(V+)
N27263145: C40.2 U13.7(V-)
N27263153: R135.2 U13.16(F\O\R\C\E\O\F\F\)
N27263155: R134.2 U13.12(FORCEON)
N27270427: R837.1 U129.10(DIR1)
N27270431: R846.2 U129.1(DIR2)
N27271424: R847.1 U130.10(DIR1)
N27271428: R848.2 U130.1(DIR2)
N27273273: R849.1 U146.10(DIR1)
N27273277: R850.2 U146.1(DIR2)
N27274474: R871.1 U147.10(DIR1)
N27274478: R872.2 U147.1(DIR2)
N27876508: D3.2(ANODE) D17.1(CATHODE) F2.2 R926.2
N28004667: R917.2 U149.1(SENSE)
N28004936: R892.2 U149.9(OUT)
N28004974: C826.1 U149.7(TIMER)
N28005348: LD9.2 R30.2
N28027381: LD14.1 Q19.3(D)
N28029912: R922.2 U149.5(EN)
N28030740: LD14.2 R923.2
N28032220: R919.2 R921.1 U149.4(UVLO)
N28032223: R918.2 R920.1 U149.3(OVP)
N28034077: J3.1 SW1.3
N28055806: F2.1 SW1.2
N28098623: D18.1(CATHODE) Q19.1(G) R924.2
N28173616: D19.1(K) LD15.2
N28350475: LD15.1 R926.1
N28489979: R737.2 R927.1 U1.L2(RSV6)
N28490065: TP143.1(TP) U1.G3(RSV7)
N28490068: TP149.1(TP) U1.Y14(RSV12)
N28490071: TP151.1(TP) U1.Y19(RSV11)
N28490074: TP145.1(TP) U1.F18(RSV8)
N28490077: TP141.1(TP) U1.H2(RSV9)
N28490080: TP150.1(TP) U1.AA18(RSV10)
N28490154: TP142.1(TP) U1.D2(RSV5)
N196364310: TP89.1(TP) U32.B8(TEST)
N284049954: R175.1 SW3.5
N284049955: R183.1 SW3.6
N284049956: R190.1 SW3.7
N284049957: R197.1 SW3.8

Pads without a net: D2 1 2; J2 10 12 14 16 17 21 23 25 27 29 31 33 36 38 40 41 43 44 45 46 49 51 53 55 57 59 61 65 67 69 71 73 74 75 79 80 81 82 84 85 86 88 90 91 93 94 99; J5 A7 B12; J7 6 13 14; J8 6 17 18 19; J18 5; J19 9 10 11 14 18 20 22 24 26 28 30 32 34 36 38 40 42 44 46 48 50 52 54 55 56 59 60; J22 35 37 38 39 40; J23 4; J31 2; J32 4; J33 4; J34 4 5 7 8 12 13 14 15 18 20 21 22 23 26 27 28 29 30 31 32 36; J36 14; J49 2 6; NOREF#5 1; NOREF#8 1; NOREF#10 1; NOREF#14 1; NOREF#19 1; NOREF#20 1; NOREF#27 1; NOREF#28 1; NOREF#29 1; NOREF#33 1; NOREF#37 1; NOREF#38 1; P1 1 4 6 7 8 9; P2 1 4 8; P3 1 4 8; RA12 1 8; RA17 3 4 5 6; SW1 1; U1 AD16 AE16; U3 3 5; U4 1; U7 2 3; U8 7; U9 E2 G1; U13 10; U17 A1 A2 A3 A12 A17 B1 B2 B17 C1 C2 C11 C16 C17 C18 C19 D1 D2 D3 D5 D10 D11 D16 D17 D18 D19 E1 E2 E3 E16 E17 F1 F2 F3 F9 G1 G2 G3 G4 G16 G18 H3 H4 H16 J1 J2 J3 J4 K3 K4 L1 L2 M2 M3 M14 N1 N2 N3 N4 N16 P1 P2 P3 P14 P15 P17 P18 P19 R5 R6 R10 R11 R12 R14 R15 R16 R17 R18 R19 T4 T5 T6 T7 T8 T9 T10 T11 T12 T13 T14 T15 T16 U4 U5 U6 U7 U8 U9 U10 U11 U12 U13 U14 U15 U16 U17 U18 U19 V1 V4 V5 V6 V7 V8 V9 V10 V11 V12 V13 V14 V15 V16 V17 V18 V19 W1 W2 W3 W4 W5 W6 W7 W8 W9 W10 W11 W12 W13 W14 W15 W16 W17 W18 W19; U20 C5 E13 E18 V13 V14 V15 V18 V19 W13 W18 W19; U24 14; U27 A3 F1 F9 H1 H9; U29 A1 A6 A7 A8 A10 A11 A12 A13 A14 B10 B11 B12 B13 B14 C8 C9 C10 C11 C12 C13 C14 D3 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H5 H12 H13 H14 J1 J2 J3 J5 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U31 10; U33 15; U37 3 6 9 10 11 12 13 14; U38 1; U39 A3 F1 F9 H1 H9; U40 4 5 6 11 12 13 14; U41 14 17; U45 A3 F1 F9 H1 H9; U47 1; U49 A3 F1 F9 H1 H9; U52 A3 F1 F9 H1 H9; U60 1 2 3 6 7; U64 10; U68 1; U72 4 5 6 11 12 13; U73 3 5; U74 1 10 11 14 15 17 18 19 22 23 24; U78 1 3 7 8; U80 1; U82 N1 N2 P1 P2 R1 R2 T1 T2; U84 1; U86 1; U87 1 2 3 4 5 6 10 11 14 15 20 21 22 23 24 35 38; U88 1; U90 6 7 9 10; U93 7 8 9 10; U94 6 7 9 10; U96 9 10 11 12 13 14 27 28 29 30 31 32; U101 1; U103 4; U107 2 5; U109 1 2 5; U111 4 9; U115 17; U118 10; U119 10; U131 1; U132 14 17; U133 5 6 7 9 10 11 12 13 14; U136 10; U140 1; U144 1; Y3 2 4; Y5 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 1347 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 4097 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3V3_CONN_FB: length 7
  TOP w0.381: U116.1 239.3,239.67 239.69,240.06 239.69,240.26 239.81,240.39 239.81,241.58 240.04,241.81 C104.2 241.96,241.81 R824.2 242.15,242 R825.2
3V3_CONN_PG: length 220.2
  TOP w0.102: v1(77.68,193.26) 77.43,193.02 U20.U15
  TOP w0.127: R852.2 234.79,239.92 234.77,239.93 TP55.1 ; R852.2 235.66,238.98 v2(235.84,239.16) ; R852.2 234.79,238.67 235.4,238.05 U116.5
  L03_SIG1 w0.127: v2(234.44,231.66) 232.92,231.66 231.44,233.14 231.44,236.41 233.2,238.17 234.85,238.17 v2(235.84,239.16) ; v2(202.18,230.01) 202.18,226.66 201.04,225.52 201.04,218.89 199.97,217.82 199.52,217.82 196.22,214.52 183.77,214.52 182.96,215.33 181.53,215.33 178.18,211.98 178.18,208.04 174.27,204.13 150.01,204.13 147.4,201.51 116.66,201.51 114.38,199.23 99.26,199.23 95.99,195.95 92.18,195.95 91.26,195.04 91.26,191.1 90.09,189.93 90.09,187.29 90.93,186.45 90.93,186.2 89.38,184.65 88.16,184.65 87.17,185.64 87.17,186.04 85.17,188.05 79.88,188.05 v2(78.84,189.09)
  L08_SIG2 w0.127: v2(234.44,231.66) 231.09,228.31 225.25,228.31 223.93,226.99 219.81,226.99 215.7,231.1 210.13,231.1 208.28,229.25 202.95,229.25 v2(202.18,230.01)
  BOTTOM w0.102: v1(77.68,193.26) 78.03,193.26 78.21,193.44 78.64,193.44 78.82,193.26 78.82,192.14 77.58,190.9 77.58,190.23 77.65,190.16
  BOTTOM w0.127: v2(78.84,189.09) 78.71,189.09 77.65,190.16
3V3_DCIN_FB: length 7
  TOP w0.254: U141.1 286.19,202.92 286.88,203.61 C806.2 288.85,203.61 R898.2 289.03,205.54 R899.2
3V3_DCIN_PG: length 233.2
  TOP w0.102: U20.W12 75.93,191.39 77.16,190.16
  TOP w0.127: 77.16,190.16 77.56,189.76 77.56,187.71 78.44,186.83 v2(79.12,186.83)
  TOP w0.254: R893.2 282.61,199.85 U141.5
  TOP w0.381: R893.2 281.68,202.41 TP200.1 282.73,202.43 v2(282.96,202.2)
  L03_SIG1 w0.127: v2(79.12,186.83) 79.5,186.83 80.06,187.39 83.13,187.39 85.34,185.18 85.34,184.7 86.51,183.53 87.12,183.53 87.76,184.16 89.92,184.16 91.19,185.43 91.19,185.71 91.95,186.48 91.95,189.04 93.55,190.64 93.98,190.64 96.77,193.44 96.77,195.49 99.67,198.39 114.81,198.39 117.22,200.8 148.23,200.8 151.03,203.6 176.58,203.6 177.67,204.69 v2(177.67,204.87) ; v2(235.2,200.17) 238.38,203.34 281.99,203.34 282.96,202.38 v2(282.96,202.2)
  L08_SIG2 w0.127: v2(177.67,204.87) 179.45,203.09 232.28,203.09 v2(235.2,200.17)
5V_EN: length 267.1
  TOP w0.102: 68.91,194.73 68.96,194.73 69.16,194.93 69.56,194.93 69.85,195.23 U20.M1 ; 68.45,194.66 68.53,194.73
  TOP w0.254: 68.53,194.73 68.91,194.73
  TOP w0.305: v2(259.84,214.52) 260.1,214.26 U18.10
  TOP w0.381: 68.45,194.66 68.33,194.53 68.33,194.2 v1(68.25,194.2)
  L03_SIG1 w0.381: v1(68.25,194.2) 68.33,194.2 68.33,194.53 68.38,194.58 68.38,195.49 65.96,197.91 63.25,197.91 61.7,196.36 60.71,196.36 59.44,197.63 v2(59.44,199.4) ; v2(228.73,203.72) 234.82,203.72 236.3,205.2 250.52,205.2 v2(259.84,214.52) 259.84,222.26 258.44,223.66 J46.2 ; v2(177.32,208.45) 176.46,208.45 174.65,206.64 163.96,206.64 163.19,207.41 128.4,207.41 116.08,219.72 93.85,219.72 92.2,218.07 92.08,218.07 88.14,214.14 62.86,214.14 61.34,215.66 v2(61.34,217.31)
  L08_SIG2 w0.381: v2(228.73,203.72) 228.35,204.1 181.68,204.1 v2(177.32,208.45) ; v2(59.44,199.4) 59.44,206.95 61.34,208.85 v2(61.34,217.31)
5V_PWRGD: length 294.6
  TOP w0.102: v1(74.22,202.18) 74.22,201.87 73.91,201.56 73.91,201.14 74.21,200.85 74.21,200.56 73.93,200.28 U20.B8
  TOP w0.254: U18.14 262.65,211.15
  TOP w0.381: v2(233.3,241.7) 233.17,241.82 233.17,243.47 233.69,244 R909.2 ; v2(228.98,205.5) 229.74,204.74 259.84,204.74 TP52.1 ; TP52.1 264.54,204.36 R908.2 ; TP52.1 261.16,207.74 261.16,209.74 261.43,210.01 R150.1 262,210.51 262.65,211.15
  L03_SIG1 w0.381: v2(176.78,209.95) 174.12,207.28 164.72,207.28 163.7,208.29 129.51,208.29 117.2,220.61 83.95,220.61 81.41,218.07 v2(81.41,217.21) ; v2(233.3,241.7) 233.3,242.08 234.06,242.84 236.73,242.84 237.36,242.2 240.03,242.2 243.33,238.9 243.33,237 242.06,235.73 240.79,235.73 239.78,234.71 239.78,228.74 236.98,225.95 236.98,212.61 229.87,205.5 v2(228.98,205.5)
  L08_SIG2 w0.381: v2(176.78,209.95) 177.8,209.95 182.75,204.99 228.47,204.99 v2(228.98,205.5)
  BOTTOM w0.203: v1(74.22,202.18) 74.8,202.76 74.8,216.04 75.97,217.21 v2(81.41,217.21)
AGND: length 94
  TOP w0.102: v1(246.79,172.79) v1(246.14,172.14)
  TOP w0.152: U32.E6 v1(246.14,174.09) 245.82,174.42 U32.E5 ; U32.J6 v1(246.14,172.14) U32.H5 ; 248.16,168.82 v1(248.16,168.8) ; 248.16,168.82 U32.N8 ; 248.16,168.82 248.16,169.47 248.05,169.58 U32.M8 ; U32.D6 v1(246.14,174.74) ; U32.K3 v1(244.84,171.49) ; v1(244.84,171.49) 244.52,171.82 U32.J3 ; v1(244.84,171.49) 245.17,171.82 U32.J4 ; U32.H6 246.47,172.47 v1(246.79,172.79) ; U32.F5 v1(245.49,173.44) U32.G4
  TOP w0.381: C121.1 257.2,177.18 v2(257.4,177.38) 257.4,178.48 v2(257.05,178.83) C116.2 ; v2(242.17,156.73) 241.6,156.73 241.35,156.99 v2(240.41,156.99) ; v2(236.96,158.28) 236.98,158.31 C161.1 C160.2 235.33,158.38 v2(235.28,158.33) 236.33,158.33 236.39,158.28 v2(236.96,158.28) ; v2(236.96,158.28) 238.34,158.28 C163.2 v2(238.76,156.86) 239.71,156.86 239.84,156.99 v2(240.41,156.99) ; v2(240.41,156.99) C164.1 ; FB15.2 v2(225.26,160.76) ; C158.2 v2(248.41,158.54) ; C152.1 v2(247.4,163.72) ; C157.2 v2(245.75,158.69) ; C151.1 v2(245.75,163.72)
  L07_GND3 w0.381: v2(257.4,177.38) 255.53,175.51 253.64,175.51 v2(253.24,175.91) 253.24,176.62 252.73,177.13 250.06,177.13 248.62,175.68 246.53,175.68 246.14,175.29 v1(246.14,174.74) v1(246.14,174.09) 246.18,174.06 246.53,174.06 246.79,173.8 v1(246.79,172.79) 245.74,172.79 245.49,173.04 v1(245.49,173.44) 244.01,173.44 243.71,173.14 243.71,172.1 244.3,171.52 244.82,171.52 v1(244.84,171.49) 244.6,171.49 244.12,171.01 244.12,168.8 ; 244.12,168.8 244.93,167.99 246.13,167.99 246.94,168.8 v1(248.16,168.8) ; 244.12,168.8 244.12,165.34 v2(245.75,163.72) 245.75,163.87 246.23,164.35 246.94,164.35 247.4,163.9 v2(247.4,163.72) 248.41,162.7 v2(248.41,158.54) 247.84,158.54 247.69,158.69 v2(245.75,158.69) 245.11,159.32 243.66,159.32 243.36,159.02 243.36,158.92 242.17,157.73 v2(242.17,156.73)
  BOTTOM w0.305: 243.84,171.59 243.94,171.49 v1(244.84,171.49)
  BOTTOM w0.381: C504.1 242.17,159.17 C505.2 v2(242.17,156.73) ; v2(253.24,175.91) 253.38,176.05 253.38,176.78 253.11,177.05 252.39,177.05 C457.2 252.24,177.88 252.21,177.9 C466.1
  BOTTOM w0.508: 243.84,171.59 243.47,171.96 C476.1 C469.2
  vias: v2(227.08,161.48) v2(227.13,160.8)
AGND_XTAL: length 29.6
  TOP w0.152: v1(247.44,172.79) 247.12,173.12 U32.G7
  TOP w0.381: v2(258.42,178.5) 258.7,178.22 C127.1 ; C132.1 v2(258.05,173.1)
  TOP w0.508: FB13.1 265.11,173.4 v2(264.6,172.9)
  L08_SIG2 w0.381: v2(258.05,173.1) 258.05,176.03 258.42,176.39 v2(258.42,178.5)
  L08_SIG2 w0.508: v1(247.44,172.79) 247.44,173.4 247.86,173.81 251.6,173.81 252.22,174.44 256.29,174.44 257.62,173.1 v2(258.05,173.1) 258.78,173.83 263.68,173.83 v2(264.6,172.9)
  BOTTOM w0.254: C472.1 247.44,173.49 v1(247.44,172.79)
AVDDA_ARMPLL: length 18.3
  TOP w0.127: U1.N6 v1(173.21,125.01)
  L08_SIG2 w0.102: 172.1,134.89 172.1,133.66 171.63,133.19 171.63,132.9 171.62,132.89 171.62,132.54 171.62,132.54 171.62,132.1 171.63,132.09 171.63,131.99 171.7,131.92 171.7,130.77 171.5,130.57 171.5,128.54 172,128.04 172,126.14 172.34,125.8 172.34,125.31 172.64,125.01 v1(173.21,125.01)
  L08_SIG2 w0.254: 172.1,134.89 172.1,134.9 172.06,134.94 172.06,135.32 171.3,136.08 171.3,136.79 v2(171.52,137.01)
  BOTTOM w0.381: v2(171.52,137.01) 171.53,137.01 171.53,137 171.55,136.97 171.96,136.97 172.07,136.86 C180.1 C174.2 174.13,136.86 FB17.2 ; v1(173.21,125.01) 172.67,125.55 C525.2
AVDDA_DDRPLL: length 30.5
  TOP w0.127: U1.W20 v1(169.21,113.01)
  TOP w0.381: C259.2 C258.1 165.82,102.59 v2(165.91,102.68) 166.34,102.25 FB27.2
  L06_PWR2 w0.127: 165.85,113.41 165.84,113.4 165.38,113.4 165.37,113.41 165.05,113.41 165.04,113.4 164.82,113.4 164.47,113.04 164.47,109.36 165.4,108.42 165.86,108.42 165.86,110 165.61,110.25 165.61,112.41 165.81,112.61 167.78,112.61 167.8,112.63 168.21,112.63 168.23,112.61 168.71,112.61 168.72,112.62 168.8,112.63 168.83,112.63 v1(169.21,113.01) 168.82,113.4 168.58,113.4 168.57,113.41 168.25,113.41 168.24,113.4 167.78,113.4 167.77,113.41 167.45,113.41 167.44,113.4 166.18,113.4 166.17,113.41 165.85,113.41
  L06_PWR2 w0.381: v2(165.91,102.68) 164.77,103.82 164.77,103.85 164.59,104.03 164.59,107.15 165.86,108.42
  BOTTOM w0.381: C623.2 169.56,112.66 v1(169.21,113.01)
AVDDA_DSSPLL: length 18.6
  TOP w0.127: U1.N20 v1(173.21,113.81)
  L08_SIG2 w0.102: 172.77,104.03 172.67,104.13 172.67,106.14 172.42,106.39 172.42,109.67 173,110.25 173,111.27 173.21,111.48 v1(173.21,113.81)
  L08_SIG2 w0.203: 172.77,104.03 172.95,103.85
  L08_SIG2 w0.381: v1(173.46,103.65) 173.15,103.65 172.95,103.85
  BOTTOM w0.381: C260.2 173.42,114.02 v1(173.21,113.81) ; v1(173.46,103.65) 173.46,103.22 173.25,103.01 171.6,103.01 170.9,102.32 FB29.2 170.75,102.44 C625.2 C249.1
AVDDA_ICSSPLL: length 18.5
  TOP w0.127: U1.G8 v1(178.01,123.41)
  BOTTOM w0.127: C577.1 183.16,125.48 183.16,124.45 182.52,123.81 180.95,123.81 180.72,123.59 180.72,122.95 179.98,122.21 178.54,122.21 178.41,122.34 U1.G8 v1(178.01,123.41)
  BOTTOM w0.381: C577.1 183.15,126.3 C210.1 183.12,126.66 183.38,126.92 184.21,126.92 185.55,128.25 188.25,128.25 189.28,127.22 FB23.2 ; v1(178.01,123.41) 177.76,123.66 C211.1
AVDDA_MAINPLL: length 19.4
  TOP w0.127: U1.M19 v1(174.01,114.61)
  TOP w0.381: v2(174.65,103.16) C261.2 C250.1
  L05_PWR1 w0.102: 173.61,110 173.61,114.21 v1(174.01,114.61)
  L05_PWR1 w0.381: 173.61,110 172.47,108.85 172.47,103.14 172.84,102.76 174.25,102.76 v2(174.65,103.16)
  BOTTOM w0.127: v1(174.01,114.61) 174.42,114.21 174.42,113.42 174.23,113.23 C624.2
  BOTTOM w0.381: FB28.2 174.01,102.52 v2(174.65,103.16)
AVDDA_NSSPLL: length 16.7
  TOP w0.127: U1.G14 v1(178.01,118.61)
  BOTTOM w0.127: v1(178.01,118.61) U1.G14 179.98,118.21 180,118.23 180.01,118.23 180.37,118.59 C594.1 180.56,118.6 180.97,119.01 182.72,119.01 C221.1
  BOTTOM w0.381: FB25.2 189.36,119.5 188.67,118.81 184.21,118.81 183.77,118.37 182.88,118.37 182.74,118.51 C221.1 182.72,119.06 C219.1
AVDDA_UARTPLL: length 18.5
  TOP w0.127: U1.G10 v1(178.81,121.01)
  BOTTOM w0.127: C592.1 180.6,121.06 180.95,121.4 181.04,121.4 181.05,121.41 182.17,121.41 182.18,121.4 182.47,121.4 182.75,121.68 182.75,121.79 ; C592.1 180.37,121.07 180.01,121.42 180,121.42 179.99,121.43 ; C592.1 179.92,120.61 179.22,120.61 v1(178.81,121.01) 179.22,121.42 179.77,121.42 179.78,121.43 179.99,121.43 ; 179.99,121.43 179.99,121.46 180.75,122.21 C218.1
  BOTTOM w0.381: FB24.2 189.19,122.27 188.85,121.93 184.28,121.93 183.77,121.43 183.12,121.43 182.75,121.79 182.77,121.81 C218.1 C217.1
DGND: length 4862.7
  TOP w0.102: 139.42,130.75 139.95,130.75 ; U52.F2 138.85,119.89 ; U27.F2 138.85,180.85 ; U39.F8 138.44,160.4 138.44,159.67 138.61,159.5 v1(139.01,159.5) 139.24,159.73 139.24,160.49 138.92,160.81 138.86,160.81 ; v1(138.84,174.68) 138.48,175.04 138.48,175.68 U27.F8 ; U49.F2 138.85,135.13 ; 138.43,145.15 138.43,144.61 v1(138.84,144.2) 139.22,144.57 139.22,145.2 U45.F8 138.43,145.15
  TOP w0.127: U20.B1 U20.A1 U20.A2 ; U1.AD8 164.41,123.41 v1(163.32,123.41) ; U1.F1 179.21,132.02 v1(178.81,132.42) ; U1.E2 179.6,128.22 ; U20.B19 U20.A19 U20.A18 ; v1(161.47,114.61) 161.86,115.01 163.58,115.01 163.59,115.01 U1.AE18 ; v1(162.05,117.81) 164.41,117.81 U1.AD14 ; U1.J1 176.81,129.03 176.76,129.08 176.76,130.7 v1(177.21,131.15) ; U1.AE11 163.13,120.61 v1(162.74,121.01) ; 179.6,132.9 v1(178.81,133.69)
  TOP w0.152: U144.3 163.42,215.25 v2(163.45,215.28) ; SW10.4 SW10.3 v2(77.69,247.9) ; Q19.2 v2(250.25,229.7) ; v2(169.43,90.21) 169.42,90.21 169.42,90.46 169.44,90.49 169.44,91.31 169.61,91.48 169.62,91.48 169.9,91.76 169.9,92.16 169.61,92.45 U67.15 ; SW6.4 SW6.3 v2(94.77,247.9) ; SW5.4 SW5.3 v2(103.35,247.9) ; SW7.4 SW7.3 v2(86.13,247.9) ; 280.9,95.36 280.9,95.88 v2(281.15,96.13) v2(280.64,96.64) ; v2(26.29,90.95) 26.02,91.21 U146.3 ; v2(120.57,248.12) 120.8,247.9 SW2.3 SW2.4 ; v1(76.43,196.74) 76.42,196.73 U20.J12 U20.H12 ; v1(76.43,196.74) 76.93,196.24 U20.K14 ; v1(76.43,196.74) U20.K13 ; D15.3 v2(215.77,25.41) ; v2(126.03,236.08) 125.98,236.13 D6.2 ; U20.H12 76.2,197.5 v1(76.2,197.58) ; U20.H12 U20.H11 ; U20.H11 U20.J11 ; U20.H11 75.43,197.71 v1(75.41,197.73) 75.41,197.75 U20.F10 ; U20.H11 U20.H10 ; C135.2 118.62,192.29 119.38,193.05 v2(119.38,193.44) ; R576.1 141.23,26.34 142.16,25.41 v2(142.16,24.35) ; 179.6,128.22 179.6,128.78 179.6,128.78 179.6,132.9 ; v2(112.12,247.9) SW4.3 SW4.4 ; U20.A1 69.98,200.73 ; v1(72.92,197.96) 72.7,197.73 U20.G5 U20.G4 ; U147.3 33.75,95.49 v2(34.16,95.9) ; U67.4 174.01,93.05 174.4,92.66 ; U20.M8 U20.L8 ; U20.M8 U20.M9 v1(74.43,194.75) ; U20.M8 v1(73.59,194.89) ; U20.L8 U20.L9 U20.K9 U20.K10 ; U20.L8 73.45,195.73 v1(73.43,195.75) 73.41,195.75 U20.K6 ; R474.2 v2(135.64,98.68) ; U6.4 280.4,97.6 ; v2(294.26,210.96) 293.63,210.33 C2.2 ; v2(263.4,213.76) 263.42,213.78 v2(263.42,216.45) ; U6.10 280.9,94.65 ; v1(74.43,194.75) 74.91,194.75 U20.N10 ; v1(74.43,194.75) 74.91,195.23 U20.M10 ; v2(79.43,201.37) 79.43,201.37 U20.A19 ; R515.2 v2(3.43,50.94) ; v2(200.53,104.15) 200.21,104.48 200.21,104.61 199.42,105.4 ; R848.1 v2(43.46,204.43) ; R872.1 v2(35.94,89.04) ; R846.1 v2(29.09,210.01) ; U52.B8 U52.A8 ; U124.3 45.35,107.93 ; SW9.4 SW9.3 ; v2(185.39,216.23) 185.85,216.23 186.08,216.46 186.08,217.66 186.01,217.73 U125.9 ; U74.2 18.67,61.72 18.86,61.53 19.38,61.53 v2(19.94,60.97) ; R850.1 v2(18.92,89.17) ; U76.3 45.54,117.86 45.97,118.3 45.97,118.32 46.16,118.51 v2(46.35,118.51) ; R584.1 v2(200.53,13.86) ; D14.3 v2(194.18,14.75) ; D18.2 v2(246.76,226.2) ; v1(181.26,133.77) 181.26,128.96 U1.C1 ; C681.2 v2(35.47,204.45) ; R915.1 v2(42.28,102.74)
  TOP w0.178: U102.43 102.42,42.24 102.23,42.05 v2(102.23,42)
  TOP w0.203: U9.A3 v2(237.24,76.44) ; U29.G5 176.76,185.38 v1(176.51,185.62) ; v2(92.58,180.23) 92.17,180.64 U24.11 ; 265.75,213.26 265.75,213.24 265.89,213.1 265.89,212.81 265.94,212.76 U18.2 ; v2(93.65,183.96) 93.33,183.64 U24.13 ; J19.57 v2(211.18,82.44) ; U32.D3 U32.C2 U32.C1 242.38,175.72 241.68,176.42 ; U107.4 235.24,25.28 v2(235.05,25.08) ; U9.B7 v2(241.24,75.64) ; v1(175.51,184.99) 176.01,184.49 U29.E7 ; v1(242.77,176.65) 243.05,176.37 U32.B1 U32.B2 ; v2(63.98,169.36) 64.48,169.86 64.48,170.03 64.49,170.04 64.49,170.46 64.48,170.47 U33.11 ; v2(94.06,42.09) 94.42,41.73 94.42,41.67 95,41.09 U102.57 ; v2(93.55,181.22) 93.55,181.9 93.3,182.14 U24.12 ; U20.W1 v2(69.98,191.28) ; U20.W1 U20.V1 ; U20.W1 U20.W2 ; U67.21 167.21,92.27 167.34,92.14 167.34,91.38 166.94,90.98 166.94,90.23 167.18,89.98 v2(167.67,89.98) ; U33.13 v2(65.79,173.61) ; U35.13 v2(93.73,171.71) ; U29.K8 175.5,186.86 175.5,185.83 v1(175.82,185.51) ; v2(93.85,170.19) 92.88,170.19 U35.12 ; v1(129.86,115.2) 129.9,115.24 129.9,115.95 C610.1 ; U115.12 294.57,57.17 v2(294.49,57.09) 294.49,57.17 295,57.69 U115.11 ; v2(65.91,172.1) 64.94,172.1 U33.12 ; 139.95,130.75 140.37,130.33 U49.D8 ; U32.J2 U32.J1 242.86,171.82 242.81,171.87 241.83,171.87 240.97,171.01 240.97,169.86 v2(239.52,168.42) ; U9.A1 v2(235.64,76.44) ; U67.45 v2(174.01,86.63) ; v2(280.64,96.64) 280.4,96.88 280.4,97.6 ; U29.C4 U29.D4 v1(177.51,184.63) ; v2(243.76,179.47) 243.64,179.59 243.64,179.97 243.41,180.2 243.41,182.06 243.03,182.44 243.03,183.25 ; v2(171.15,89.71) 171.15,90.77 171.32,90.95 171.32,92.41 171.61,92.7 U67.10 ; U102.70 v2(94.95,34.59) ; U49.F8 139.27,130.75 139.42,130.75 ; v2(293.09,57.09) 293.07,57.11 U115.13 ; U9.C3 v2(237.24,74.84) ; U32.A7 247.98,177.88 v2(247.98,177.76) ; U67.28 v2(167.21,86.63) ; U35.11 92.42,168.57 92.58,168.41 92.58,168.12 v2(91.92,167.45) ; U9.E3 v2(237.24,73.24) ; v2(47.65,208.24) 47.13,208.77 U130.3 ; v2(248.59,177.48) 248.37,177.27 248.02,177.27 U32.A8 ; v1(242.8,177.28) 243.06,177.02 U32.A1 ; v1(174.03,186.09) 174.24,185.88 U29.H10 ; C257.2 v2(36.13,66.98) ; U67.34 v2(169.61,86.63) ; 248.84,171.69 248.72,171.82 U32.J8 U32.J7 ; U9.D7 v2(241.24,74.04) ; U29.P6 U29.N5 U29.P4 177.51,189.79 v2(178.05,190.33) ; U67.39 v2(171.61,86.63) ; J22.36 52.14,62.56 v2(51.77,62.93) ; C256.2 v2(34.36,67.62)
  TOP w0.229: v2(224.41,88.91) 224.14,89.18 U132.12 ; U132.13 v2(224.41,90.68)
  TOP w0.254: J36.17 v2(83.5,15.29) ; U41.13 v2(219.87,99.11) ; J19.16 v2(221.68,72.88) ; U27.N9 133.25,174.95 133.25,174.94 133.25,174.8 v1(133.08,174.64) ; 284.89,198.55 284.24,197.9 U141.8 ; 284.89,198.55 U141.7 ; 284.89,198.55 v2(285.22,198.87) 284.24,199.85 U141.4 ; v2(157.66,144.92) 157.66,145.61 157.78,145.73 U112.2 ; v2(292.39,215.53) C23.2 v2(292.39,212.58) ; 97.13,38.07 v2(97.49,37.71) ; 97.13,38.07 97.12,38.07 97.1,38.09 ; 97.13,38.07 97.11,38.09 97.1,38.09 ; v1(143.25,121.09) U52.A1 U52.B2 ; U39.L9 134.85,159.38 134.85,159.37 134.85,158.8 v1(134.76,158.71) ; 97.1,38.09 U102.63 ; U39.B1 v1(142.45,166.81) ; U52.A8 v1(143.25,114.69) ; U118.1 28.75,187.94 v2(28.75,189.27) ; v1(134.84,167.65) 134.85,167.65 134.85,166.94 134.85,166.94 U39.L1 ; v2(245.62,148.99) 245.61,148.99 U44.7 ; v1(134.84,137.17) 134.85,137.17 134.85,135.93 U49.L1 ; C288.1 v2(26.8,61.23) ; U17.J7 v1(238.22,52.45) ; C816.2 v2(37.76,209.12) ; v2(285.95,206.42) 285.93,206.39 C810.2 ; 189.56,13.55 189.31,13.55 v2(188.95,13.91) ; 189.56,13.55 C355.2 ; 189.56,13.55 v2(189.03,13.02) ; U17.K9 v1(239.82,51.65) ; v2(88.75,21.25) 88.75,21.24 U108.19 ; J36.2 v2(91,15.29) ; U42.7 275.22,150.01 275.36,150.15 v2(276.12,150.15) ; U68.3 v2(42,119.63) ; U27.B8 v1(142.45,175.65) ; 237.11,239.97 237.35,239.73 U116.4 ; U39.D1 140.45,166.44 v1(140.06,166.83) ; v1(133.08,144.16) 133.25,144.32 U45.N9 ; 69.98,200.73 69.78,200.73 v2(69.6,200.55) ; U81.R3 v1(151.85,65.31) ; v2(204.72,133.31) 204.67,133.36 C795.2 ; R899.1 287.74,206.32 v2(287.76,206.34) ; U1.AE1 v1(163.61,129.01) ; U81.D3 v1(161.45,65.31) ; v1(141.48,174.37) 141.49,174.37 141.49,174.38 141.25,174.61 U27.C9 ; C162.1 v2(229.53,98.27) ; J2.9 192.28,246.7 v2(191.92,246.34) ; v2(201.17,148.35) 201.13,148.31 U64.8 ; U17.L8 v1(239.02,50.05) ; U17.L10 v1(241.42,50.05) ; R71.2 v2(128.02,228.87) ; U39.C9 140.89,159.65 v1(140.89,159.07) ; U45.B2 U45.A1 v1(143.25,151.57) ; U64.9 v2(201.13,151.33) ; U17.K7 v1(238.22,51.65) ; v1(139.25,165.2) 138.85,165.61 U39.F2 ; U17.M11 v1(242.22,49.25) ; U82.N3 v1(128.05,64.92) ; U17.P11 v1(242.22,47.65) ; R902.2 v2(217.68,209.12) ; C822.2 v2(28.31,95.41) ; v2(245.34,38.75) 245.34,39.27 245.06,39.55 C85.1 ; v2(253.42,139.66) 253.37,139.71 U48.2 ; U17.N11 v1(242.22,48.45) ; v2(137.65,87.7) 138.24,88.28 138.81,88.28 138.92,88.17 U62.9 ; v1(132.55,167.11) 133.25,166.41 U39.N1 ; U39.A8 v1(143.25,160.41) ; U82.G4 v1(133.65,63.32) ; U102.55 96.14,42.48 95.83,42.79 94.76,42.79 v2(94.06,42.09) ; U20.P16 77.93,193.89 v1(78.03,193.79) 78.09,193.73 U20.R17 U20.R18 ; U81.K4 v1(155.85,63.71) ; v2(48.46,62.93) 48.46,62.39 48.64,62.21 J22.29 ; J36.8 v2(88,15.29) ; U27.N1 133.25,181.65 v1(132.55,182.35) ; v2(238.73,141.37) 238.75,141.35 U46.1 ; FB13.2 v2(265.56,175.12) ; v1(248.22,59.02) U17.A19 ; C798.2 v2(108.84,196.15) ; v2(248.01,104.82) 248.02,104.8 U12.25 ; U49.L9 134.85,129.06 134.76,128.97 v1(134.76,128.23) ; U109.4 200.27,15.26 200.55,14.99 C354.1 ; U82.B4 v1(137.65,63.32) ; C804.2 v2(291.22,200.16) ; U52.N1 133.25,120.69 v1(132.55,121.39) ; C811.2 280.58,205.52 v2(280.62,205.55) ; U17.K1 v1(233.42,51.65) ; U81.G4 v1(159.05,63.71) ; v2(172.9,51.63) 173.47,52.2 U92.29 ; v2(245.59,140.15) 245.3,139.85 U46.7 ; U52.D1 141.5,121.74 v2(141.5,122.57) ; U82.K3 v1(130.45,64.92) ; U92.13 176.49,48.88 176.58,48.78 177.32,48.78 v2(177.91,49.38) ; v1(162.05,117.81) 161.92,117.69 161.92,117.62 161.46,117.15 C202.2 ; U45.L1 134.85,152.4 v1(134.84,152.41) ; U1.AE25 163.19,108.6 v1(162.23,108.6) ; v2(193.85,97.58) 193.69,97.41 C265.2 194.4,96.53 194.92,96.02 U56.2 ; U49.B2 U49.A1 143.33,136.41 v1(144.4,136.41) ; U47.3 212.87,89.18 v2(212.85,89.17) ; v2(274.9,45.75) 274.9,44.65 275.34,44.21 275.34,43.11 ; U17.H9 v1(239.82,53.25) ; U27.J1 136.45,181.98 136.45,182.85 v1(136.48,182.88) ; U39.J1 136.45,166.82 136.45,167.61 v1(136.48,167.64) ; v2(254.58,138.93) 255.04,138.93 255.26,138.71 U48.7 ; R913.1 195.33,142.64 v2(194.82,143.14) ; U52.B1 v1(142.45,121.09) ; U27.L1 134.85,181.93 134.85,181.93 134.85,182.89 v1(134.84,182.89) ; U39.B2 U39.A1 v1(143.25,166.81) ; U80.3 108.44,18.82 v2(108.08,18.46) ; v1(139.25,115.49) 138.86,115.09 U52.F8 ; U27.D8 140.45,176.05 v1(140.86,175.65) 140.46,175.25 U27.D9 ; C813.2 v2(217.73,211.1) ; U69.8 v2(281.25,52.99) ; v2(286.77,52.59) 286.36,52.99 U69.9 ; J36.5 v2(89.5,15.29) ; U17.M4 v1(235.82,49.25) ; U17.M5 v1(236.62,49.25) ; U49.B8 v1(142.45,129.93) ; U27.A8 v1(143.25,175.65) ; 265.75,213.26 U18.3 264.42,213.26 v2(264.16,212.99) ; U81.N4 v1(153.45,63.71) ; U81.E3 v1(160.65,65.31) ; U81.B3 v1(163.05,65.31) ; v1(136.48,121.92) 136.45,121.89 U52.J1 ; U49.N9 133.25,129.53 133.25,129.08 v1(133.08,128.92) ; U27.B2 U27.A1 v1(143.25,182.05) ; U17.K8 v1(239.02,51.65) ; U8.6 v2(196.84,231.08) ; v1(133.08,159.4) 133.25,159.56 U39.N9 ; C206.2 188.85,92.84 v2(188.85,93.49) ; U17.M6 v1(237.42,49.25) ; J22.3 35.64,60.52 v2(35.51,60.39) ; 248.84,171.69 249.21,171.33 249.93,171.33 250.23,171.63 253.28,171.63 v2(253.57,171.34) ; C825.2 v2(265.5,226) ; C825.2 v2(262.71,227.8) ; C825.2 263.9,226.2 v2(263.02,226.2) ; U96.42 275.84,43.76 275.67,43.92 v2(275.67,44.57) ; U98.4 v2(38.6,165.42) ; U49.N1 133.25,135.93 v1(132.55,136.63) ; v1(136.48,137.16) 136.45,137.13 U49.J1 ; U52.D9 140.46,114.29 v1(140.86,114.69) 140.45,115.09 U52.D8 ; C165.1 v2(229.53,101.66) ; U53.4 43.26,76.38 v2(43.76,75.88) U53.8 ; U17.J9 v1(239.82,52.45) ; U17.K10 v1(241.42,51.65) ; U81.K3 v1(155.85,65.31) ; U45.A8 v1(143.25,145.17) ; U17.K11 v1(242.22,51.65) ; U27.B1 v1(142.45,182.05) ; U108.14 85.5,21.3 v2(85.66,21.45) ; v1(136.45,143.46) U45.J9 ; U45.J1 136.45,152.37 v1(136.48,152.4) ; U49.B1 142.05,136.39 142.11,136.45 v1(142.11,137.33) ; U81.N3 v1(153.45,65.31) ; v1(136.45,112.98) U52.J9 ; U45.D8 140.45,145.57 v1(140.86,145.17) 140.46,144.77 U45.D9 ; U17.H1 v1(233.42,53.25) ; v1(134.76,112.99) 134.76,113.73 134.85,113.82 U52.L9 ; U81.M3 v1(154.25,65.31) ; U82.D4 v1(136.05,63.32) ; v2(264.67,97.3) 264.68,97.31 R889.1 ; C278.2 195.22,92.93 194.92,92.62 194.92,92.48 v2(194.86,92.48) ; v2(162.43,220.23) 162.42,220.22 C815.2 ; U17.H8 v1(239.02,53.25) ; U95.4 v2(294.73,33.9) ; R836.1 v2(49.91,106.06) ; C235.2 v2(44.65,69.48) ; v1(134.84,121.93) 134.85,121.93 134.85,120.69 U52.L1 ; v1(162.74,125.81) 162.74,125.64 163.07,125.31 163.91,125.31 U1.AE5 ; R901.1 280.16,196.64 v2(280.11,196.59) ; U81.M4 v1(154.25,63.71) ; U17.N5 v1(236.62,48.45) ; U82.K4 v1(130.45,63.32) ; v2(254.76,151.02) 254.49,150.75 U43.1 ; U1.F3 v1(178.81,127.41) ; U42.1 268.95,151.51 268.48,151.98 268.48,152.54 v2(268.45,152.57) ; C817.2 v2(38.76,206.72) ; v1(132.55,151.87) 133.25,151.17 U45.N1 ; U81.D4 v1(161.45,63.71) ; U17.H15 v1(245.42,53.25) ; U17.K2 v1(234.22,51.65) ; 138.85,180.85 v1(139.25,180.44) ; C794.2 203.6,135.38 v2(203.07,135.9) ; U1.U7 v1(170.81,124.21) U1.T6 ; v2(131.27,24.5) 131.07,24.69 U106.3 ; U39.B8 v1(142.45,160.41) ; U39.D9 140.46,160.01 v1(140.86,160.41) 140.45,160.81 U39.D8 ; U41.12 v2(219.85,100.61) ; U81.E4 v1(160.65,63.71) ; J36.11 v2(86.5,15.29) ; U17.L3 v1(235.02,50.05) ; U81.R4 v1(151.85,63.71) ; U17.M10 v1(241.42,49.25) ; v1(133.08,113.68) 133.25,113.84 133.25,114.29 U52.N9 ; U82.E3 v1(135.25,64.92) ; 138.85,135.13 v1(139.25,134.72) ; U82.M4 v1(128.85,63.32) ; v2(174.62,139.28) 173.81,139.28 173.4,138.87 C182.2 ; v1(140.06,151.59) 140.45,151.2 U45.D1 ; v1(134.76,143.47) 134.85,143.56 134.85,144.33 134.85,144.33 U45.L9 ; U49.C9 141.25,129.2 v1(140.97,128.92) ; U17.M1 v1(233.42,49.25) ; U27.D1 140.45,181.68 v1(140.06,182.07) ; U41.11 v2(220.55,101.56) ; 138.85,119.89 v1(139.25,119.48) ; U86.3 9.65,42.73 v2(9.65,41.92) ; U82.B3 v1(137.65,64.92) ; R903.2 v2(204.23,208.13) ; U42.2 268.7,151.01 268.47,150.78 268.47,150.48 v2(268.15,150.15) ; U43.7 259.22,149.25 v2(259.26,149.21) ; U82.N4 v1(128.05,63.32) ; U81.G3 v1(159.05,65.31) ; U82.D3 v1(136.05,64.92) ; U27.L9 134.85,174.92 134.85,174.92 134.85,174.04 v1(134.76,173.95) ; U17.J10 v1(241.42,52.45) ; U82.G3 v1(133.65,64.92) ; U49.D8 140.45,130.33 v1(140.86,129.93) 140.46,129.53 U49.D9 ; U82.R3 v1(126.45,64.92) ; U78.4 v2(97.36,92.51) ; U39.J9 136.45,159.3 136.45,159.3 v1(136.45,158.7) ; C334.1 164.65,49.08 164.54,49.19 v2(164.39,49.19) ; v1(139.25,149.96) 138.85,150.37 U45.F2 ; 280.9,94.65 280.9,95.36 ; v1(136.45,128.22) U49.J9 ; R354.1 v2(218.85,103.29) ; C820.2 v2(28.31,92.1) ; U1.Y23 v1(167.61,110.61) ; v1(139.55,138.22) 139.69,138.22 140.45,137.47 U49.D1 ; C335.1 v2(165.23,43.75) ; U17.L9 v1(239.82,50.05) ; v2(45.16,108.57) 45.35,108.38 45.35,107.93 ; U27.J9 136.45,174.69 136.45,174.69 v1(136.45,173.94) ; U17.J11 v1(242.22,52.45) ; U82.E4 v1(135.25,63.32) ; U17.M7 v1(238.22,49.25) ; U17.H2 v1(234.22,53.25) ; U82.R4 v1(126.45,63.32) ; Q12.2 v2(40.78,78.94) ; U44.1 240.68,150.49 v2(240.92,150.26) ; U45.B1 v1(142.45,151.57) ; U49.A8 v1(143.25,129.93) ; U45.B8 v1(142.45,145.17) ; R812.2 v2(202.82,144.17) ; U17.L5 v1(236.62,50.05) ; C284.2 v2(42.96,122.44) ; U81.B4 v1(163.05,63.71) ; U17.L7 v1(238.22,50.05) ; U82.M3 v1(128.85,64.92) ; C812.1 v2(205.39,213.13) ; U17.L11 v1(242.22,50.05) ; U45.C9 141.25,144.44 141.33,144.36 v1(141.33,144.01) ; U52.C9 v1(140.85,113.89) ; U17.N12 v1(243.02,48.45) ; U17.J8 v1(239.02,52.45)
  TOP w0.279: C222.2 v2(44.27,82.32)
  TOP w0.305: R73.2 v2(200.15,230.39) ; C62.1 v2(233.93,99.96) ; v2(99.26,98.82) 99.31,98.77 FL8.2 ; C780.1 v2(214.62,88.03) ; R259.1 v2(106.68,178.45) ; v2(271.15,214.47) C75.2 v2(271.15,218.48) ; C33.1 v2(59.94,219.68) ; R152.1 v2(225.18,46.93) ; J21.2 v2(67.03,56.8) ; U4.3 v2(287.57,99.94) ; v2(92.48,111.32) 92.23,111.07 U51.9 ; U132.11 v2(223.65,88.23) ; v2(222.38,83.85) 221.61,84.61 R864.1 ; v2(182.74,198.84) U34.2 ; C63.2 263.02,217.39 263.42,216.98 v2(263.42,216.45) ; C258.2 165.31,101.91 165.84,101.39 v2(167.13,101.39) ; v2(212.4,55.08) 212.34,55.02 C622.2 ; v2(266.19,211.09) 266.19,209.13 265.97,208.91 R157.1 ; U1.A1 184.15,129.55 v1(185.29,129.55) ; FL5.2 v2(253.21,43.5) ; C133.2 v2(176.78,200.36) ; C19.2 v2(187.87,232.55) ; C73.2 v2(254.74,44.39) ; v2(229.62,80.15) 229.62,80.66 229.76,80.8 R349.1 ; R84.2 v2(273.41,93.33) ; C41.1 v2(26.42,234.58) ; C32.2 58.29,219.98 v2(57.43,219.12) ; C28.1 v2(257.01,94.88) ; U26.2 100.97,179.47 v2(101.6,180.1) ; FL3.2 v2(253.14,47.26) ; R252.2 v2(69.8,161.94) ; U23.2 101.73,184.42 v2(102.23,184.93) ; C66.2 v2(254.86,48.07) ; C34.1 v2(61.47,219.68) ; R262.1 v2(64.39,179.51) ; R342.1 v2(220.71,86.01) ; v2(259.69,42.48) FL14.1 v2(257.91,43.88) ; C76.2 v2(271.27,209.13) ; R79.2 v2(257.01,93.36) ; v2(230.11,65.99) R96.2 R97.2 R99.2 R98.2 v2(236.69,65.99) ; J21.8 v2(73.63,54.6) ; C781.1 214.62,91.51 v2(214.63,91.51) ; R218.2 v2(62.71,161.71) ; v2(85.73,178.32) 85.19,178.32 84.96,178.09 R272.1 ; C74.2 v2(270.41,213.76) ; C15.2 v2(193.67,234.62) ; C24.2 v2(279.76,102.48) ; J21.7 63.44,52.64 v2(61.85,52.64) ; v2(293.2,100.66) 293.29,100.76 293.29,101.28 292.99,101.59 U2.2 ; C40.1 v2(24.13,234.58) ; R78.2 v2(257.01,96.41) ; R302.1 v2(41.66,175.02) ; C31.2 v2(123.46,230.76) ; R782.2 v2(260.42,48.71) ; R783.1 v2(254.49,105.69) ; C21.2 v2(187.87,230.9) ; C122.2 v2(42.66,180.86) ; C113.2 v2(172.08,173.56) ; C46.1 v2(246.51,84.85) ; C25.1 v2(278.99,104.51) ; R165.1 v2(225.18,48.58)
  TOP w0.381: v2(190.6,88.41) 191.09,88.9 C213.2 ; FL7.2 116.69,95.62 v2(116.46,95.39) ; JP1.84 302.51,40.6 ; JP1.84 301.46,39.54 ; JP1.84 303.57,39.54 ; JP1.84 302.51,38.49 ; JP1.61 299.97,68.54 ; JP1.61 299.97,66.43 ; JP1.61 298.92,67.48 ; JP1.61 301.03,67.48 ; U59.2 188.37,138.57 188.82,138.11 188.82,137.35 188.44,136.97 188.43,136.97 188.39,136.93 186.4,136.93 186.28,136.82 184.31,136.82 v1(181.26,133.77) ; C605.2 140.93,123.75 141.14,123.55 141.17,123.55 141.52,123.2 141.52,122.7 141.5,122.69 v2(141.5,122.57) ; R839.1 v2(170.08,208.32) ; C56.1 257.66,217.18 257.38,217.46 v2(257.38,218) ; 301.45,188.71 J12.40 ; J12.40 303.53,188.71 ; J12.40 302.49,189.75 ; J12.40 302.49,187.66 ; C129.1 v2(120.27,196.99) ; v2(194.06,208.14) 193.71,208.14 193.04,208.81 C763.1 ; C58.1 v2(26.37,220.34) ; TP204.1 114.24,201.94 115,202.71 v2(115.57,202.71) ; TP204.1 110.87,200.94 ; TP204.1 110.11,201.18 ; TP204.1 110.87,203.09 110.74,203.21 TP203.1 ; v2(118.9,207.23) 118.9,205.43 U25.1 ; JP1.31 301.03,105.58 ; JP1.31 299.97,106.64 ; JP1.31 298.92,105.58 ; JP1.31 299.97,104.53 ; v2(194.06,231.41) v2(194.06,232.3) ; J9.3 93.09,193.11 ; J9.3 94.16,192.04 ; J9.3 93.09,190.97 ; J9.3 92.02,192.04 ; 266.29,83.11 TP129.1 ; TP129.1 266.29,85.12 ; TP129.1 267.3,84.11 ; TP129.1 265.29,84.11 ; 269.95,178.45 J17.1 ; J17.1 271.02,177.38 ; J17.1 272.08,178.45 ; J17.1 271.02,179.52 ; 298.91,216.65 J12.17 ; J12.17 299.95,217.69 ; J12.17 300.99,216.65 ; J12.17 299.95,215.6 ; 299.97,23.25 JP1.95 ; JP1.95 298.92,24.3 ; JP1.95 301.03,24.3 ; JP1.95 299.97,25.36 ; TP202.1 195.19,49.9 ; TP202.1 193.18,49.9 ; TP202.1 194.18,48.9 ; TP202.1 194.18,50.9 ; C358.2 v2(116.46,15.71) ; J10.2 62.92,191.02 ; J10.2 60.78,191.02 ; J10.2 61.85,189.96 ; R637.1 197.6,222.75 v2(198.27,222.08) ; C166.2 291.59,151.88 v2(292.07,151.4) C167.2 ; 158.6,229.11 TP201.1 ; TP201.1 158.6,231.12 ; TP201.1 159.6,230.11 ; TP201.1 157.59,230.11 ; C49.2 255.48,222.43 254.88,223.03 C50.2 v2(254.78,223.9) ; C49.2 v2(257.23,220.36) ; C49.2 255.48,219.34 ; J12.43 299.95,184.67 ; J12.43 299.95,182.58 ; J12.43 300.99,183.63 ; U1.N7 v1(174.01,123.41) U1.M8 ; U1.N7 v1(174.01,124.21) U1.M6 ; U1.N7 U1.P8 v1(172.41,122.61) U1.R9 ; R786.2 v2(99.71,195.61) ; C261.1 C250.2 175.86,101.94 176.05,102.12 176.05,102.99 175.41,103.62 175.41,104.56 174.81,105.16 v1(174.81,105.6) ; U12.17 v2(253.59,96.79) ; C786.2 207.59,146.35 v2(207.59,146.34) ; 301.45,229.35 J12.8 ; J12.8 302.49,228.3 ; J12.8 302.49,230.39 ; J12.8 303.53,229.35 ; C326.2 283.79,43.96 v2(283.87,43.88) ; R45.2 250.44,87.77 250.16,88.05 v2(250.16,88.1) ; v2(83.13,170.07) C143.2 C136.1 ; 301.45,206.49 J12.26 ; J12.26 303.53,206.49 ; J12.26 302.49,207.53 ; J12.26 302.49,205.44 ; J11.3 99.36,189.75 ; J11.3 97.23,189.75 ; J11.3 98.3,190.82 ; J11.3 98.3,188.69 ; v2(249.43,16.78) 251.21,16.78 251.61,16.37 C7.2 251.11,15.76 v2(249.43,15.76) ; v2(49.28,114.21) 48.64,114.85 R834.1 ; MOD1.K 72.23,227.36 ; MOD1.K 70.82,225.95 ; MOD1.K 73.64,225.95 ; MOD1.K 72.23,224.54 ; U126.8 173.31,212.55 173.94,211.93 v2(173.96,211.95) ; 267.73,184.16 TP92.1 ; TP92.1 269.74,184.16 ; TP92.1 268.73,183.16 ; TP92.1 268.73,185.17 ; 301.46,59.86 JP1.68 ; JP1.68 302.51,60.92 ; JP1.68 302.51,58.81 ; JP1.68 303.57,59.86 ; v2(119.66,124.92) 119.66,125.49 119.38,125.77 C668.2 ; U1.G19 v1(178.01,114.61) U1.H18 v1(177.21,115.41) U1.J17 v1(176.41,116.21) U1.K16 v1(175.61,117.01) U1.L15 v1(174.81,117.81) U1.M14 v1(174.01,118.61) U1.N13 v1(173.21,119.41) U1.P12 v1(172.41,120.21) U1.R11 ; C371.2 v2(221.23,231.54) ; v2(242.95,27.83) 242.91,27.79 C356.2 241.09,27.79 240.79,27.49 C359.2 ; Q14.2 v2(71.86,132.6) ; v2(203.71,244.49) 203.04,243.83 C5.2 ; C140.1 234.69,170.94 C137.1 238.18,170.94 C138.1 ; D9.2 v2(98.99,236.74) 99.23,236.98 C799.2 ; J18.3 269.93,123.71 ; J18.3 268.86,124.78 ; J18.3 267.79,123.71 ; J18.3 268.86,122.65 ; J7.10 106.71,208.87 ; J7.10 106.71,206.76 ; J7.10 105.65,207.81 ; R638.1 v2(189.84,220.28) ; Q11.2 v2(58.63,131.19) ; C315.2 v2(88.24,40.73) ; R318.2 194.86,169.69 194.47,169.31 v2(193.67,169.31) ; v2(297,38.12) 297,38.11 296.67,38.45 R563.2 ; v2(113.61,94.96) 113.42,95.15 C293.1 ; TP62.1 243.3,216.22 ; TP62.1 242.3,217.22 ; TP62.1 242.3,215.22 ; TP62.1 241.3,216.22 ; JP1.56 303.57,75.1 ; JP1.56 302.51,76.16 ; JP1.56 301.46,75.1 ; JP1.56 302.51,74.05 ; JP1.13 301.03,128.44 ; JP1.13 299.97,127.39 ; JP1.13 298.92,128.44 ; 119.65,108.46 119.93,108.46 119.93,108.46 C677.2 121.03,107.46 120.52,106.95 v2(120.52,105.81) ; 119.65,108.46 119.89,108.22 v2(119.89,106.95) ; 119.65,108.46 C678.2 ; C757.2 v2(135,100.5) ; 299.97,89.29 JP1.43 ; JP1.43 301.03,90.34 ; JP1.43 298.92,90.34 ; JP1.43 299.97,91.4 ; 11.68,107.39 P1.5 ; P1.5 11.68,109.5 ; P1.5 12.74,108.45 ; P1.5 10.63,108.45 ; U1.F20 v1(178.81,113.01) U1.G21 v1(178.01,113.01) U1.H20 U1.J19 v1(176.41,114.61) U1.K18 U1.L17 v1(174.81,116.21) U1.M16 v1(174.01,117.01) U1.N15 v1(173.21,117.81) U1.P14 v1(172.41,117.81) U1.R15 v1(171.61,117.01) U1.T16 U1.U17 v1(170.01,115.41) U1.V18 ; R431.1 v2(202.4,111.27) ; JP1.37 301.03,97.96 ; JP1.37 299.97,96.91 ; JP1.37 298.92,97.96 ; JP1.37 299.97,99.02 ; J2.83 165.61,247.08 v2(165.63,247.06) ; 299.97,112.15 JP1.25 ; JP1.25 301.03,113.2 ; JP1.25 298.92,113.2 ; JP1.25 299.97,114.26 ; JP1.91 301.03,29.38 ; JP1.91 298.92,29.38 ; JP1.91 299.97,28.33 ; JP1.91 299.97,30.44 ; U5.3 v2(221.58,242.42) ; 302.51,43.57 JP1.80 ; JP1.80 301.46,44.62 ; JP1.80 303.57,44.62 ; JP1.80 302.51,45.68 ; 255.48,219.34 255.8,219.01 v2(257.2,219.01) ; 255.48,219.34 C48.2 255.48,215.23 255.11,214.86 254.57,214.86 v2(254.51,214.92) ; J6.2 15.21,236.55 ; J6.2 16.37,235.4 ; J6.2 15.21,234.24 ; J6.2 14.06,235.4 ; U133.8 228.87,88.37 v2(228.98,88.25) ; C399.1 239.08,35.99 238.12,36.94 238.12,37.23 237.97,37.38 v2(237.97,37.75) ; U1.G15 v1(178.01,117.81) U1.H14 U1.J13 v1(176.41,119.41) U1.K12 v1(175.61,120.21) U1.L11 v1(174.81,121.01) U1.M10 v1(174.81,121.81) U1.L9 ; J12.7 300.99,229.35 ; J12.7 299.95,230.39 ; J12.7 299.95,228.3 ; J12.7 298.91,229.35 ; v2(106.05,90.18) C303.2 v2(104.74,91.36) ; 298.92,37 JP1.85 ; JP1.85 301.03,37 ; JP1.85 299.97,38.06 ; JP1.85 299.97,35.95 ; U93.15 v2(29.26,124.53) ; U1.W13 v1(169.21,119.41) U1.V12 U1.W11 v1(169.21,121.01) U1.V10 U1.W9 ; JP1.67 301.03,59.86 ; JP1.67 299.97,58.81 ; JP1.67 298.92,59.86 ; 10.58,225.59 TP53.1 ; TP53.1 11.58,226.6 ; TP53.1 11.58,224.59 ; TP53.1 12.59,225.59 ; v2(288.42,106.75) 289.07,106.1 D2.5 ; v2(128.34,105.33) 128.67,105.66 C759.1 130.67,105.66 131.07,106.06 131.07,106.44 ; R426.2 v2(46.05,83.12) ; 301.46,90.34 JP1.44 ; JP1.44 302.51,91.4 ; JP1.44 303.57,90.34 ; JP1.44 302.51,89.29 ; 301.45,198.87 J12.32 ; J12.32 302.49,197.82 ; J12.32 302.49,199.91 ; J12.32 303.53,198.87 ; C324.2 109.25,23.05 v2(109.04,22.85) ; J34.44 v2(125.45,15.86) J34.42 v2(131.52,15.86) J34.43 v2(137.79,15.86) J34.41 v2(141.45,15.86) ; Q10.2 v2(29.78,240.08) ; J38.5 v2(195.78,12.42) ; U1.W9 v1(169.21,122.61) U1.V8 U1.W7 ; U1.W9 v1(168.41,121.81) U1.Y10 ; v2(208.03,182.39) 208.07,182.43 U127.3 ; v2(151.38,130.7) 152.65,130.7 152.91,130.45 C227.2 152.91,129.55 152.55,129.2 151.49,129.2 v2(151.46,129.17) ; v2(232.84,13.68) 232.87,13.65 J37.12 ; C269.2 v2(151.95,94.93) ; 302.51,51.19 JP1.74 ; JP1.74 302.51,53.3 ; JP1.74 303.57,52.24 ; JP1.74 301.46,52.24 ; U97.3 v2(288.25,36.51) ; FL15.1 v2(250.42,31.51) ; 240.82,193.66 v2(240.79,193.64) C95.2 ; U75.2 v2(283.46,50.46) ; C173.2 v2(292.23,143.52) ; 302.49,230.84 J12.6 ; J12.6 301.45,231.89 ; J12.6 303.53,231.89 ; JP1.79 299.97,45.68 ; JP1.79 299.97,43.57 ; JP1.79 298.92,44.62 ; JP1.79 301.03,44.62 ; R701.2 v2(207.97,172.89) ; 303.57,136.06 JP1.8 301.46,136.06 ; JP1.62 303.57,67.48 ; JP1.62 301.46,67.48 ; JP1.62 302.51,68.54 ; JP1.62 302.51,66.43 ; 298.92,19.22 JP1.99 ; JP1.99 299.97,20.28 ; JP1.99 299.97,18.17 ; JP1.99 301.03,19.22 ; v2(94.35,95.28) C296.2 v2(93.14,93.87) ; C81.2 v2(292.23,241.85) ; v2(264.72,80.76) 264.67,80.71 J8.4 ; C350.2 v2(208.91,24.07) ; C311.2 v2(179.12,55.89) ; 301.46,120.82 JP1.20 ; JP1.20 303.57,120.82 ; JP1.20 302.51,121.88 ; JP1.20 302.51,119.77 ; U84.3 v2(283.32,61.33) ; J35.4 v2(219.31,23.06) ; R35.1 v2(261.02,19.03) ; C319.2 91.26,41.01 90.93,40.68 v2(90.93,40.17) ; C93.2 v2(85.09,195.59) ; v2(237.49,177.05) 238.24,176.31 C125.1 ; 301.45,214.11 J12.20 ; J12.20 302.49,215.15 ; J12.20 302.49,213.06 ; J12.20 303.53,214.11 ; v2(239.52,167.53) 239.9,167.15 C149.1 ; v2(184.94,182.41) 185.26,182.74 185.26,183.45 C146.2 ; 299.97,81.67 JP1.49 ; JP1.49 299.97,83.78 ; JP1.49 301.03,82.72 ; JP1.49 298.92,82.72 ; v2(133.96,81.78) 133.89,81.71 C295.1 ; C224.1 C264.2 C231.1 193.18,106.88 193.8,107.5 v2(193.8,108.22) ; v2(280.39,89.02) 281.14,89.02 281.4,89.27 C16.2 281.4,89.52 281.14,89.78 v2(280.39,89.78) ; v2(289.7,36.48) C322.1 C323.2 290.03,38.48 289.79,38.72 v2(289.79,39.92) ; Q8.2 v2(62.82,131.19) ; JP1.38 302.51,99.02 ; JP1.38 301.46,97.96 ; JP1.38 302.51,96.91 ; JP1.38 303.57,97.96 ; J2.3 v2(194.18,249.95) ; U140.3 131.26,30.1 v2(131.27,30.09) ; U30.9 v2(79.62,171.73) ; R808.1 v2(134.84,53.01) ; C283.1 v2(138.24,81.82) ; v2(203.71,240.17) 203.04,240.83 C5.2 ; U40.10 195.78,186.2 196.06,186.48 196.06,187.16 v2(196.11,187.21) ; U1.K8 v1(176.41,122.61) U1.J9 v1(177.21,121.81) U1.H10 v1(178.01,121.01) U1.G11 ; U1.K8 U1.L9 ; U1.K8 U1.L7 U1.M8 ; U9.J1 v2(235.51,69.64) ; 302.51,127.39 JP1.14 ; JP1.14 301.46,128.44 ; JP1.14 303.57,128.44 ; U108.6 88.75,27.06 v2(88.75,27.07) ; v1(170.81,119.41) U1.U13 v1(170.01,118.61) U1.V14 U1.W15 ; J5.A12 217.7,227.02 v2(217.86,226.86) ; R36.2 255.91,29.86 255.52,29.48 255.52,29.22 v2(255.4,29.1) 255.4,28.34 255.77,27.96 Q6.2 ; C338.2 12.12,64.06 v2(12.12,64.1) ; 299.97,51.19 JP1.73 ; JP1.73 298.92,52.24 ; JP1.73 301.03,52.24 ; JP1.73 299.97,53.3 ; v2(135.4,92.99) 136.5,92.99 R483.2 ; TP51.1 5.54,22.46 ; TP51.1 4.53,21.45 ; TP51.1 6.54,21.45 ; TP51.1 5.54,20.45 ; v2(249.81,244.87) 250.95,246.01 LD9.1 ; J2.87 164.34,247.31 v2(164.67,246.98) ; v2(156.08,122.67) 155.93,122.82 C203.1 ; 301.45,178.55 J12.48 ; J12.48 302.49,177.5 ; J12.48 302.49,179.59 ; J12.48 303.53,178.55 ; v2(201.78,242.61) 202.08,242.31 C5.2 ; 164.01,25.83 J31.1 ; J31.1 163.03,26.81 ; J31.1 164.01,27.79 ; J31.1 164.99,26.81 ; C783.1 v2(233.78,110.81) ; C240.2 v2(143.93,100.85) ; C126.1 v2(252.11,176.28) ; C372.2 v2(221.23,229.88) ; C172.2 v2(172.72,148.48) ; J2.2 v2(194.82,238.61) ; 302.49,174.96 J12.50 ; J12.50 302.49,177.05 ; J12.50 303.53,176.01 ; J12.50 301.45,176.01 ; 299.97,119.77 JP1.19 ; JP1.19 299.97,121.88 ; JP1.19 301.03,120.82 ; JP1.19 298.92,120.82 ; C233.2 v2(143.82,104.15) ; C365.2 204.47,239.66 v2(203.96,239.16) ; 302.51,112.15 JP1.26 ; JP1.26 302.51,114.26 ; JP1.26 303.57,113.2 ; JP1.26 301.46,113.2 ; v2(128.19,100.45) 129.51,101.77 U122.2 ; C370.2 v2(221.23,233.19) ; v2(179.5,43.7) 179.5,44.42 U89.3 ; R499.1 180.2,87.79 180.47,87.52 180.47,86.27 v2(180.29,86.1) ; U119.1 v2(30.43,151.88) ; 103.64,167.63 TP90.1 ; TP90.1 104.65,166.63 ; TP90.1 105.65,167.63 ; TP90.1 104.65,168.63 ; J2.6 v2(193.55,238.61) ; 259.77,13.13 J1.5 260.5,13.13 ; C12.1 286.69,96 v2(287.15,95.54) ; R75.1 v2(274.47,93.59) ; C598.1 v2(152.4,124.35) ; C777.2 C778.2 157.75,97.46 v2(156.79,98.42) ; J7.4 106.71,216.49 ; J7.4 105.65,215.43 ; J7.4 106.71,214.38 ; 174.4,92.66 174.47,92.66 175.51,91.61 v2(175.51,90.82) ; FB41.2 v2(286.38,35.7) ; v2(113.89,93) 113.39,92.5 FL9.2 ; C273.2 v2(121.92,93.01) ; 241.83,81.54 J4.6 ; J4.6 241.83,83.64 ; J4.6 240.78,82.59 ; J4.6 242.89,82.59 ; C177.2 174.85,155.16 174.58,155.43 173.27,155.43 v2(173.25,155.41) ; C177.2 174.85,153.89 174.58,153.62 173.42,153.62 v2(173.35,153.68) ; C177.2 v2(173.3,154.55) ; U1.M8 U1.N9 v1(173.21,121.81) U1.P10 U1.N11 v1(174.01,120.21) U1.M12 v1(174.81,119.41) U1.L13 U1.K14 v1(176.41,117.81) U1.J15 v1(177.21,117.01) U1.H16 v1(178.01,116.21) U1.G17 ; C185.1 v2(169.8,140.95) ; C291.2 v2(13.75,57.29) ; TP203.1 111.75,204.36 ; TP203.1 111.5,205.12 ; 57.93,223.21 MOD1.11 57.93,224.78 ; 299.95,197.82 J12.31 ; J12.31 299.95,199.91 ; J12.31 300.99,198.87 ; JP1.100 302.51,20.28 ; JP1.100 301.46,19.22 ; JP1.100 303.57,19.22 ; JP1.100 302.51,18.17 ; U38.4 v2(203.08,170.93) ; v2(244.02,89.93) 244.02,89.93 U12.4 ; v2(141.48,99.46) 141.86,99.07 C254.2 ; U131.3 v2(222.64,248.44) ; U116.8 237.3,236.1 v2(237.39,236.01) ; 87.44,101.34 TP104.1 ; TP104.1 88.44,102.34 ; TP104.1 89.45,101.34 ; TP104.1 88.44,100.33 ; U71.3 v1(190.81,73.82) ; R829.1 178.48,229.11 178.88,229.5 v2(179.45,229.5) ; v2(116.38,17.21) 116.41,17.24 C357.2 ; C238.2 v2(140.21,102.81) ; R528.2 178.45,49.91 v2(177.91,49.38) ; 298.92,136.06 JP1.7 301.03,136.06 ; C156.2 244.1,159.14 v2(244.78,158.46) ; v2(219.41,149.19) 218.14,149.19 217.86,148.91 C214.2 ; U58.3 v2(80.14,50.48) ; C294.1 v2(274.57,50.52) ; C668.2 C667.2 116.91,126.75 115.82,127.83 v2(115.82,129.35) ; C668.2 C669.2 122.67,126.75 122.99,127.07 v2(122.99,129.45) ; C818.2 v2(43.47,213.34) ; v2(238.63,167.91) 238,167.27 C148.1 ; C290.2 14.99,58.96 v2(14.99,59.81) U73.4 ; v2(253.72,165.09) 253.63,165 C154.1 ; v2(73.53,205.5) 73.24,205.79 C69.2 ; U128.9 v2(197.6,217.06) U128.8 ; v2(287.63,98.67) 286.76,98.67 C26.2 286.6,97.91 v2(287.63,97.91) ; v2(97.49,37.71) 97.94,37.71 98.07,37.84 v2(99.64,37.84) ; J8.12 269.75,80.69 v2(269.7,80.74) ; v2(94.97,180.18) 95.26,179.89 R5.1 ; D17.2 v2(252.6,236.49) ; 298.92,75.1 JP1.55 ; JP1.55 301.03,75.1 ; JP1.55 299.97,76.16 ; JP1.55 299.97,74.05 ; v2(253.31,160.85) 253.38,160.91 C155.1 ; C782.1 230.43,94.71 v2(230.4,94.68) ; U31.9 v2(54.22,174.27) ; J5.A15 v2(217.8,224.02) ; C266.2 v2(147.99,98.19) ; D10.2 v2(90.87,236.49) ; LD6.1 v2(261.49,24.91) ; v2(237.39,237.02) 237.11,236.75 U116.7 ; J2.77 v2(167.51,247.08) ; U103.2 v2(101.24,51.81) ; v2(135.41,106.31) 135.41,106.67 135.05,107.03 C758.1 R833.2 ; v2(76.5,229.58) R198.1 R191.1 R184.1 R176.1 v2(76.5,234.15) ; U1.L9 U1.K10 v1(176.41,121.01) U1.J11 v1(177.21,120.21) U1.H12 ; v2(188.47,199.58) 188.39,199.66 U36.3 185.9,199.66 185.08,198.84 v2(182.74,198.84) ; v2(160.35,153.84) 158.49,151.98 158.29,151.98 157.91,151.6 C710.1 ; 302.49,182.58 J12.44 ; J12.44 301.45,183.63 ; J12.44 303.53,183.63 ; J12.44 302.49,184.67 ; U11.4 v2(257.51,60.77) ; C305.2 v2(18.14,55.65) ; v2(120.65,203.34) 120.65,202.33 120.9,202.07 C117.2 ; v2(288.26,93.33) 288.26,94.09 288.52,94.34 C10.2 288.77,94.34 289.03,94.09 v2(289.03,93.23) ; J2.60 v2(176.4,238.61) ; C819.2 v2(46.87,213.34) ; J8.16 v2(272.29,80.81) ; C236.2 v2(143.93,102.38) ; C336.2 v2(162.74,51.58) ; v2(193.4,141.44) 192.99,141.85 192.59,141.85 192.56,141.87 C784.1 ; v2(238.02,193.84) 234.47,193.84 233.93,193.31 C96.2 ; C255.2 v2(149.09,101.32) ; v2(172.47,238.65) 171.96,239.16 J2.64 ; v2(181.43,52.95) 181.24,52.95 180.83,53.35 C330.2 ; v2(182.65,246.73) 182.93,246.73 183.39,247.18 J2.37 ; C821.2 v2(25.53,96.42) ; C97.2 235.97,192.11 236.51,192.66 237.4,192.66 237.41,192.67 v2(238.38,192.67) ; J8.20 274.83,76.75 v2(274.8,76.72) ; J2.18 v2(189.74,239.03) ; 163.07,240.49 v2(163.07,239.03) ; U1.W17 v1(169.21,116.21) U1.V16 v1(170.01,117.01) U1.U15 v1(170.81,117.81) U1.T14 U1.R13 U1.T12 U1.U11 v1(170.81,121.01) U1.T10 U1.U9 v1(170.81,122.61) U1.T8 U1.R7 v1(172.41,124.21) U1.P6 ; R517.1 v2(120.74,64.28) ; J37.6 v2(236.99,24.6) ; J12.49 299.95,177.05 ; J12.49 300.99,176.01 ; J12.49 299.95,174.96 ; J2.47 180.21,246.95 v2(180.19,246.93) ; R319.1 v2(233.78,105.58) ; v2(238.86,38.22) 238.86,38.66 C57.1 C86.1 ; JP1.86 302.51,38.06 ; JP1.86 303.57,37 ; JP1.86 301.46,37 ; JP1.86 302.51,35.95 ; J8.10 268.48,80.74 v2(268.43,80.79) ; v2(209.98,89.68) 209.93,89.73 C532.2 ; v2(162,247.06) 161.8,247.26 J2.95 ; FB33.2 v2(5.6,68.98) ; C750.2 v2(292.08,236.34) ; C1.2 v2(94.26,117.86) ; R68.2 v2(279.04,91.41) ; C809.2 277.92,198.98 v2(277.88,199.02) ; Q15.2 v2(66.89,131.29) ; U1.T20 v1(171.61,113.81) U1.R19 v1(172.41,114.61) U1.P18 U1.N19 v1(174.01,113.81) U1.M20 U1.N21 U1.P20 ; C17.1 v2(281.17,91.41) ; v2(222.45,105.93) 222.7,106.18 U134.8 ; U30.8 v2(71.51,171.73) ; R548.2 v2(171.75,65.08) ; v2(169.6,43.63) 169.54,43.68 C341.2 ; C346.2 v2(177.2,44.35) ; v2(77.34,211.72) 77,212.06 U16.4 v2(77,215.43) ; U116.4 237.35,238.07 v2(237.39,238.04) ; v2(234.82,35.45) 234.91,35.36 C388.2 ; D7.2 v2(108.27,236.11) ; v2(264.95,15.38) 264.44,14.87 R34.1 ; C314.2 v2(39.12,191.01) ; U60.4 v2(131.32,92.55) ; C134.2 v2(55.33,171.85) ; U1.K20 v1(175.61,113.81) U1.L19 v1(174.81,114.61) U1.M18 v1(174.01,115.41) U1.N17 v1(173.21,116.21) U1.P16 U1.R17 v1(171.61,115.41) U1.T18 v1(170.81,114.61) U1.U19 v1(170.01,113.81) U1.V20 ; 302.51,104.53 JP1.32 ; JP1.32 303.57,105.58 ; JP1.32 301.46,105.58 ; JP1.32 302.51,106.64 ; C30.1 v2(270.23,65.34) ; v2(277.47,49.31) 276.88,49.31 276.61,49.04 C316.2 ; R385.1 R386.1 163.07,149.95 v2(163.58,150.46) ; R443.1 144.64,109.31 144.06,108.73 144.06,108.67 144.06,108.67 144.06,108.17 144.41,107.83 144.9,107.83 144.91,107.84 145.77,107.84 v2(146.35,108.42) ; C209.1 v2(152.4,127.4) ; U1.H6 U1.G7 v1(178.81,123.41) U1.F8 ; C13.2 v2(287.32,93.97) ; C792.2 42.43,107.98 v2(42.93,108.47) ; U1.J7 v1(176.41,124.21) U1.K6 ; 43.5,100.07 J49.1 ; J49.1 44.55,101.12 ; J49.1 45.61,100.07 ; J49.1 44.55,99.01 ; v2(236.75,38.37) 236.58,38.55 C87.1 ; R263.1 60.35,178.87 60.81,178.87 v2(61.21,178.46) ; Q7.2 251.59,28.04 251.21,28.42 251.21,28.97 v2(250.82,29.35) 251.33,29.86 R37.2 ; R40.1 24.2,237.87 v2(24.94,237.12) ; R283.1 55.88,179.47 v2(55.37,179.97) ; U21.2 87.14,187.1 88.66,188.62 R229.1 90.35,188.62 90.59,188.86 v2(91.3,188.86) ; v2(161.01,246.9) 161.16,247.06 J2.97 ; v2(252.3,180.53) 251.74,179.97 C112.1 ; D13.2 v2(283.11,171.19) ; C756.1 v2(125.27,103.06) ; C117.2 v2(121.67,203.34) ; C117.2 122.56,202.07 122.83,202.34 v2(122.83,203.34) ; J12.5 300.99,231.89 ; J12.5 298.91,231.89 ; J12.5 299.95,230.84 ; J5.A4 217.83,237.02 v2(218.06,237.25) ; R567.2 v2(167.69,44.59) ; C318.1 v2(41.72,157.8) ; C239.1 142.23,102.26 141.99,102.5 v2(141.99,103.39) ; C239.1 143.01,102.26 143.26,102.5 v2(143.26,103.39) ; C239.1 v2(142.62,103.39) ; R479.2 v2(134.27,94.76) ; J2.63 171.96,246.98 v2(171.93,246.95) ; C793.2 v2(122.43,224.55) ; C331.2 v2(43.07,124.53) ; U29.N2 U29.N1 179.84,188.38 v2(179.9,188.32) ; 105.65,205.27 J7.12 ; J7.12 106.71,204.22 ; J7.12 106.71,206.33 ; C178.1 v2(166.75,140.95) ; v2(238.05,38.5) 238.05,39.37 C59.1 ; v2(288.44,91.84) 287.71,92.57 286.88,92.57 R44.2 ; C268.1 v2(124.11,99.33) ; Y8.4 v2(138.47,77.52) ; J7.8 106.71,211.41 ; J7.8 106.71,209.3 ; J7.8 105.65,210.35 ; U125.8 186.01,215.62 v2(185.39,216.23) ; J5.B4 v2(210.57,237.02) ; C274.2 v2(133.68,98.16) ; C78.2 v2(254.81,40.71) ; C84.2 v2(167.29,209.73) ; C169.2 v2(291.72,145.3) ; D8.2 v2(116.77,236.17) ; C91.2 v2(85.6,197.25) ; R787.1 v2(223.23,151.25) ; v2(193.5,92.12) 193.16,91.78 U50.2 192.48,91.89 U50.5 ; U10.2 v2(120.9,227.09) ; R455.2 v2(39.75,71.33) ; C214.2 217.86,147.31 218.14,147.03 v2(219.53,147.03) ; C214.2 v2(219.51,148.02) ; v2(197.79,109.11) C225.1 C229.1 197.92,107.84 v2(197.97,107.79) ; R868.2 v2(233.86,108.78) ; R487.2 v2(119.63,89.59) ; U88.3 v2(180.88,43.28) ; R523.1 v2(142.85,52.27) ; J5.B7 v2(210.57,234.02) ; v2(202.48,14.99) C354.1 ; U1.G13 v1(178.01,119.41) ; R226.2 v2(80.26,186.65) ; J23.5 v2(8.68,59.5) ; v2(109.22,90.44) 109.79,90.44 110.07,90.16 U79.8 ; C467.1 52.08,179.68 v2(52.1,179.67) ; C187.1 v2(165.23,140.95) ; v2(246.93,184.47) 246.33,184.47 246.1,184.24 C108.2 246.39,182.61 246.39,181.74 247,181.13 C114.1 ; v2(146.19,97.44) 145.16,97.44 C262.2 ; 302.51,23.25 JP1.96 ; JP1.96 301.46,24.3 ; JP1.96 302.51,25.36 ; JP1.96 303.57,24.3 ; C92.2 v2(64.9,197.12) ; R315.2 v2(209.09,167.42) ; U1.G9 v1(178.01,122.61) U1.H8 v1(177.21,123.41) ; C11.2 v2(274.55,95.75) ; v2(174.62,139.28) 175.2,139.28 175.25,139.33 175.26,139.33 175.53,139.6 R737.1 ; C131.1 v2(55.33,173.75) ; U91.3 v2(113.3,54.6) ; R604.2 v2(203.96,232.04) ; Y8.2 v2(133.57,79.12) ; 301.46,82.72 JP1.50 ; JP1.50 303.57,82.72 ; JP1.50 302.51,81.67 ; JP1.50 302.51,83.78 ; C208.1 v2(156.08,125.87) ; U1.E22 v1(179.61,111.41) ; R522.2 v2(120.74,62.12) ; C106.1 83.03,183.78 v2(82.47,184.34) ; C271.2 v2(206.14,93.61) ; C179.1 v2(168.27,140.95) ; v2(241.3,34.94) 241.27,34.97 C90.1 ; Q9.2 v2(25.21,239.98) ; C351.1 v2(181.01,23.65) ; C785.1 v2(204.42,146.15) ; C313.2 v2(44.3,155.55) ; C109.2 83.16,181.88 82.45,182.59 v2(82.45,182.67) ; C762.2 v2(192.1,222.58) ; C327.2 v2(166.8,39.64) ; R535.1 v2(274.83,49.16) ; D12.2 v2(271.12,171.19) ; U31.8 v2(46.11,174.27) ; C317.2 v2(41.72,164.53) ; U100.4 v2(33.93,200.88) ; R840.1 v2(183.67,208.03) ; C130.1 v2(112.9,196.99) ; C8.2 v2(258.09,19.83) ; C366.2 v2(204.09,238.01) ; J2.19 189.1,247.03 v2(188.85,246.78) ; U13.14 v2(26.76,225.31) ; U1.A25 183.31,109.41 v2(183.81,108.91) ; v1(140.85,113.89) 141.24,113.5 141.24,111.21 C603.2 ; C277.2 v2(121.29,89.59) ; U1.F6 v1(178.81,125.01) ; C258.2 C259.1 ; C147.2 v2(193.73,168.56) ; J2.22 v2(188.47,239.03) ; C321.2 v2(36.79,199.86) ; v2(267.23,80.81) 267.21,80.79 267.21,78.72 ; C9.2 v2(254.66,16.52) ; U135.2 v2(209.42,150.26) ; C557.1 v2(154.3,132.73) ; C320.1 v2(35.83,192.27) ; C286.2 v2(14.99,65.38) ; C308.2 v2(22.35,96.42) ; v2(111.58,100.45) 110.57,100.45 110.07,99.95 C292.2 111.11,98.45 111.58,98.92 v2(111.58,99.58) ; C168.2 v2(211.71,87.26) ; J5.B13 v2(207.39,226.02) ; D11.2 v2(82.61,236.62) ; U126.9 173.31,220.33 v2(173.1,220.54) ; R793.1 v2(120.65,205.37) ; C150.1 v2(243.97,163.72) ; R438.2 v2(37.72,77.41) ; U72.10 v2(204.55,72.66) ; C374.2 v2(204.09,230.39) ; R841.1 179.47,214.34 v2(178.79,214.34) ; C272.1 v2(120.27,93.01) ; U14.4 v2(66.59,215.56) ; U1.R23 v1(171.61,110.61) ; J2.42 v2(182.12,239.03)
  TOP w0.508: v2(285.9,243.37) J3.2 ; J3.2 v2(282.96,245.05) ; J3.2 v2(280.04,243.37) ; FB15.1 226.37,159.88 v2(225.25,159.88) ; FL2.1 204.66,217.69 v2(205.17,217.18) ; v2(276.33,240.12) J3.3 ; J3.3 v2(278.16,243.02) ; J3.3 v2(278.16,237.4) ; J5.B18 v2(207.42,221.02) ; v2(218.06,220.61) 218.06,220.67 217.71,221.02 J5.A18 ; v2(222.12,227.98) 222,227.85 220.85,227.85 220.48,228.22 ; C360.2 115.49,18.48 v2(115.49,18.48) ; C360.2 115.49,22.64 v2(115.49,22.65) ; C360.2 v2(114.1,20.54) ; 220.48,228.22 220.48,228.37 220.85,228.74 221.39,228.74 v2(221.49,228.64) ; 220.48,228.22 C369.2 ; R887.2 v2(282.7,64.78) ; C741.2 v2(239.09,243.35) ; R825.1 240.85,245.22 240.22,245.85 C742.2 236,245.85 235.74,245.58 235.74,241.35 237.11,239.97 ; C325.2 v2(113.06,33.39) ; C735.2 v2(93.85,44.59) ; J5.B16 v2(207.38,223.02)
  TOP w0.61: U57.1 191.87,28.01 v2(191.74,27.88) ; U54.1 v2(212.4,55.08)
  L02_GND1 w0.508: 299.97,28.33 JP1.91 ; JP1.91 299.97,30.44 ; JP1.91 301.03,29.38 ; JP1.91 298.92,29.38 ; J3.2 282.96,244.44 ; J3.2 280.75,243.37 ; J3.2 285.17,243.37 ; J3.2 282.96,242.31 ; 302.51,135.01 JP1.8 ; JP1.8 303.57,136.06 ; JP1.8 302.51,137.12 ; JP1.8 301.46,136.06 ; 299.97,112.15 JP1.25 ; JP1.25 301.03,113.2 ; JP1.25 299.97,114.26 ; JP1.25 298.92,113.2 ; 72.23,224.54 MOD1.K ; MOD1.K 70.82,225.95 ; MOD1.K 73.64,225.95 ; MOD1.K 72.23,227.36 ; 302.51,127.39 JP1.14 ; JP1.14 303.57,128.44 ; JP1.14 301.46,128.44 ; JP1.14 302.51,129.5 ; J12.40 303.53,188.71 ; J12.40 301.45,188.71 ; J12.40 302.49,189.75 ; J12.40 302.49,187.66 ; JP1.7 301.03,136.06 ; JP1.7 299.97,137.12 ; JP1.7 298.92,136.06 ; JP1.7 299.97,135.01 ; 93.09,190.97 J9.3 ; J9.3 94.16,192.04 ; J9.3 92.02,192.04 ; J9.3 93.09,193.11 ; J7.12 106.71,206.33 ; J7.12 107.76,205.27 ; J7.12 106.71,204.22 ; J7.12 105.65,205.27 ; J7.10 107.76,207.81 ; J7.10 106.71,208.87 ; J7.10 105.65,207.81 ; J7.10 106.71,206.76 ; 14.06,235.4 J6.2 ; J6.2 15.21,236.55 ; J6.2 15.21,234.24 ; J6.2 16.37,235.4 ; 267.73,184.16 TP92.1 ; TP92.1 268.73,183.16 ; TP92.1 268.73,185.17 ; TP92.1 269.74,184.16 ; JP1.99 299.97,20.28 ; JP1.99 301.03,19.22 ; JP1.99 298.92,19.22 ; JP1.99 299.97,18.17 ; 299.97,140.09 JP1.3 ; JP1.3 298.92,141.14 ; JP1.3 301.03,141.14 ; JP1.3 299.97,142.2 ; 241.83,81.54 J4.6 ; J4.6 240.78,82.59 ; J4.6 242.89,82.59 ; J4.6 241.83,83.64 ; 105.65,210.35 J7.8 ; J7.8 107.76,210.35 ; J7.8 106.71,209.3 ; J7.8 106.71,211.41 ; J12.44 303.53,183.63 ; J12.44 301.45,183.63 ; J12.44 302.49,182.58 ; J12.44 302.49,184.67 ; P1.5 12.74,108.45 ; P1.5 11.68,109.5 ; P1.5 11.68,107.39 ; P1.5 10.63,108.45 ; 301.46,97.96 JP1.38 ; JP1.38 302.51,99.02 ; JP1.38 302.51,96.91 ; JP1.38 303.57,97.96 ; 299.95,174.96 J12.49 ; J12.49 300.99,176.01 ; J12.49 299.95,177.05 ; J12.49 298.91,176.01 ; 298.92,75.1 JP1.55 ; JP1.55 299.97,76.16 ; JP1.55 299.97,74.05 ; JP1.55 301.03,75.1 ; J12.26 302.49,207.53 ; J12.26 302.49,205.44 ; J12.26 301.45,206.49 ; J12.26 303.53,206.49 ; JP1.1 301.03,143.68 ; JP1.1 298.92,143.68 ; JP1.1 299.97,144.74 ; JP1.1 299.97,142.63 ; 109.74,204.36 TP203.1 ; TP203.1 110.74,203.35 ; TP203.1 110.74,205.36 ; TP203.1 111.75,204.36 ; JP1.32 303.57,105.58 ; JP1.32 302.51,106.64 ; JP1.32 302.51,104.53 ; JP1.32 301.46,105.58 ; J12.43 299.95,184.67 ; J12.43 298.91,183.63 ; J12.43 300.99,183.63 ; J12.43 299.95,182.58 ; JP1.84 303.57,39.54 ; JP1.84 302.51,38.49 ; JP1.84 301.46,39.54 ; JP1.84 302.51,40.6 ; 301.46,52.24 JP1.74 ; JP1.74 302.51,53.3 ; JP1.74 303.57,52.24 ; JP1.74 302.51,51.19 ; 5.54,20.45 TP51.1 ; TP51.1 5.54,22.46 ; TP51.1 4.53,21.45 ; TP51.1 6.54,21.45 ; 299.97,58.81 JP1.67 ; JP1.67 298.92,59.86 ; JP1.67 301.03,59.86 ; JP1.67 299.97,60.92 ; J11.3 99.36,189.75 ; J11.3 98.3,190.82 ; J11.3 98.3,188.69 ; J11.3 97.23,189.75 ; 60.78,191.02 J10.2 ; J10.2 62.92,191.02 ; J10.2 61.85,192.09 ; J10.2 61.85,189.96 ; 301.46,37 JP1.86 ; JP1.86 302.51,38.06 ; JP1.86 302.51,35.95 ; JP1.86 303.57,37 ; 158.6,229.11 TP201.1 ; TP201.1 157.59,230.11 ; TP201.1 158.6,231.12 ; TP201.1 159.6,230.11 ; 109.87,201.94 TP204.1 ; TP204.1 111.87,201.94 ; TP204.1 110.87,200.94 ; TP204.1 110.87,202.95 ; 299.97,137.55 JP1.5 ; JP1.5 301.03,138.6 ; JP1.5 298.92,138.6 ; JP1.5 299.97,139.66 ; JP1.31 299.97,106.64 ; JP1.31 299.97,104.53 ; JP1.31 298.92,105.58 ; JP1.31 301.03,105.58 ; 57.93,224.78 MOD1.11 57.93,223.21 ; J12.17 299.95,217.69 ; J12.17 299.95,215.6 ; J12.17 298.91,216.65 ; J12.17 300.99,216.65 ; 298.92,67.48 JP1.61 ; JP1.61 299.97,66.43 ; JP1.61 299.97,68.54 ; JP1.61 301.03,67.48 ; 299.97,51.19 JP1.73 ; JP1.73 299.97,53.3 ; JP1.73 301.03,52.24 ; JP1.73 298.92,52.24 ; 302.51,119.77 JP1.20 ; JP1.20 303.57,120.82 ; JP1.20 301.46,120.82 ; JP1.20 302.51,121.88 ; JP1.44 302.51,91.4 ; JP1.44 303.57,90.34 ; JP1.44 302.51,89.29 ; JP1.44 301.46,90.34 ; 298.91,229.35 J12.7 ; J12.7 299.95,228.3 ; J12.7 300.99,229.35 ; J12.7 299.95,230.39 ; 302.51,23.25 JP1.96 ; JP1.96 301.46,24.3 ; JP1.96 303.57,24.3 ; JP1.96 302.51,25.36 ; 104.65,166.63 TP90.1 ; TP90.1 105.65,167.63 ; TP90.1 103.64,167.63 ; TP90.1 104.65,168.63 ; JP1.68 303.57,59.86 ; JP1.68 302.51,60.92 ; JP1.68 302.51,58.81 ; JP1.68 301.46,59.86 ; 302.51,112.15 JP1.26 ; JP1.26 303.57,113.2 ; JP1.26 302.51,114.26 ; JP1.26 301.46,113.2 ; J12.50 302.49,177.05 ; J12.50 302.49,174.96 ; J12.50 301.45,176.01 ; J12.50 303.53,176.01 ; 301.46,67.48 JP1.62 ; JP1.62 303.57,67.48 ; JP1.62 302.51,66.43 ; JP1.62 302.51,68.54 ; JP1.50 303.57,82.72 ; JP1.50 301.46,82.72 ; JP1.50 302.51,83.78 ; JP1.50 302.51,81.67 ; 301.45,178.55 J12.48 ; J12.48 302.49,179.59 ; J12.48 303.53,178.55 ; J12.48 302.49,177.5 ; 299.95,197.82 J12.31 ; J12.31 298.91,198.87 ; J12.31 299.95,199.91 ; J12.31 300.99,198.87 ; 278.16,237.91 J3.3 ; J3.3 277.09,240.12 ; J3.3 279.22,240.12 ; J3.3 278.16,242.33 ; 299.97,89.29 JP1.43 ; JP1.43 298.92,90.34 ; JP1.43 299.97,91.4 ; JP1.43 301.03,90.34 ; 301.46,44.62 JP1.80 ; JP1.80 303.57,44.62 ; JP1.80 302.51,43.57 ; JP1.80 302.51,45.68 ; 299.97,127.39 JP1.13 ; JP1.13 299.97,129.5 ; JP1.13 301.03,128.44 ; JP1.13 298.92,128.44 ; 106.71,214.38 J7.4 ; J7.4 106.71,216.49 ; J7.4 105.65,215.43 ; J7.4 107.76,215.43 ; 259.77,14.59 J1.5 260.5,13.86 ; J12.8 302.49,230.39 ; J12.8 303.53,229.35 ; J12.8 301.45,229.35 ; J12.8 302.49,228.3 ; 302.49,230.84 J12.6 ; J12.6 303.53,231.89 ; J12.6 301.45,231.89 ; J12.6 302.49,232.93 ; 299.95,230.84 J12.5 ; J12.5 298.91,231.89 ; J12.5 300.99,231.89 ; J12.5 299.95,232.93 ; 267.72,206.05 TP61.1 ; TP61.1 266.71,207.05 ; TP61.1 267.72,208.05 ; TP61.1 268.72,207.05 ; J18.3 269.93,123.71 ; J18.3 268.86,122.65 ; J18.3 268.86,124.78 ; J18.3 267.79,123.71 ; JP1.49 299.97,83.78 ; JP1.49 298.92,82.72 ; JP1.49 301.03,82.72 ; JP1.49 299.97,81.67 ; 88.44,100.33 TP104.1 ; TP104.1 88.44,102.34 ; TP104.1 89.45,101.34 ; TP104.1 87.44,101.34 ; JP1.37 299.97,99.02 ; JP1.37 299.97,96.91 ; JP1.37 301.03,97.96 ; JP1.37 298.92,97.96 ; 298.92,24.3 JP1.95 ; JP1.95 301.03,24.3 ; JP1.95 299.97,25.36 ; JP1.95 299.97,23.25 ; J49.1 45.61,100.07 ; J49.1 44.55,101.12 ; J49.1 43.5,100.07 ; J49.1 44.55,99.01 ; TP62.1 243.3,216.22 ; TP62.1 242.3,215.22 ; TP62.1 241.3,216.22 ; TP62.1 242.3,217.22 ; 299.97,35.95 JP1.85 ; JP1.85 299.97,38.06 ; JP1.85 298.92,37 ; JP1.85 301.03,37 ; 298.92,44.62 JP1.79 ; JP1.79 301.03,44.62 ; JP1.79 299.97,43.57 ; JP1.79 299.97,45.68 ; 10.58,225.59 TP53.1 ; TP53.1 11.58,224.59 ; TP53.1 11.58,226.6 ; TP53.1 12.59,225.59 ; JP1.19 301.03,120.82 ; JP1.19 299.97,119.77 ; JP1.19 298.92,120.82 ; JP1.19 299.97,121.88 ; JP1.56 302.51,76.16 ; JP1.56 301.46,75.1 ; JP1.56 302.51,74.05 ; JP1.56 303.57,75.1 ; 301.45,198.87 J12.32 ; J12.32 302.49,199.91 ; J12.32 303.53,198.87 ; J12.32 302.49,197.82 ; J17.1 272.08,178.45 ; J17.1 269.95,178.45 ; J17.1 271.02,179.52 ; J17.1 271.02,177.38 ; 301.45,214.11 J12.20 ; J12.20 303.53,214.11 ; J12.20 302.49,213.06 ; J12.20 302.49,215.15 ; 163.03,26.81 J31.1 ; J31.1 164.01,27.79 ; J31.1 164.01,25.83 ; J31.1 164.99,26.81 ; 193.18,49.9 TP202.1 ; TP202.1 194.18,48.9 ; TP202.1 195.19,49.9 ; TP202.1 194.18,50.9 ; TP129.1 266.29,85.12 ; TP129.1 265.29,84.11 ; TP129.1 266.29,83.11 ; TP129.1 267.3,84.11 ; 302.51,18.17 JP1.100 ; JP1.100 303.57,19.22 ; JP1.100 302.51,20.28 ; JP1.100 301.46,19.22
  L03_SIG1 w0.508: P1.5 12.74,108.45 ; P1.5 10.63,108.45 ; P1.5 11.68,107.39 ; P1.5 11.68,109.5 ; J12.44 302.49,184.67 ; J12.44 303.53,183.63 ; J12.44 301.45,183.63 ; J12.44 302.49,182.58 ; J12.43 300.99,183.63 ; J12.43 298.91,183.63 ; J12.43 299.95,182.58 ; J12.43 299.95,184.67 ; J9.3 93.09,193.11 ; J9.3 93.09,190.97 ; J9.3 92.02,192.04 ; J9.3 94.16,192.04 ; J31.1 164.99,26.81 ; J31.1 164.01,27.79 ; J31.1 163.03,26.81 ; J31.1 164.01,25.83 ; J12.40 302.49,189.75 ; J12.40 301.45,188.71 ; J12.40 302.49,187.66 ; J12.40 303.53,188.71 ; 302.49,228.3 J12.8 ; J12.8 301.45,229.35 ; J12.8 303.53,229.35 ; J12.8 302.49,230.39 ; 302.49,213.06 J12.20 ; J12.20 301.45,214.11 ; J12.20 302.49,215.15 ; J12.20 303.53,214.11 ; 301.46,75.1 JP1.56 ; JP1.56 302.51,76.16 ; JP1.56 303.57,75.1 ; JP1.56 302.51,74.05 ; J12.17 299.95,217.69 ; J12.17 299.95,215.6 ; J12.17 298.91,216.65 ; J12.17 300.99,216.65 ; 87.44,101.34 TP104.1 ; TP104.1 88.44,102.34 ; TP104.1 88.44,100.33 ; TP104.1 89.45,101.34 ; 109.87,201.94 TP204.1 ; TP204.1 110.87,202.95 ; TP204.1 111.87,201.94 ; TP204.1 110.87,200.94 ; TP202.1 194.18,50.9 ; TP202.1 195.19,49.9 ; TP202.1 194.18,48.9 ; TP202.1 193.18,49.9 ; 278.16,237.91 J3.3 ; J3.3 277.09,240.12 ; J3.3 278.16,242.33 ; J3.3 279.22,240.12 ; 105.65,205.27 J7.12 ; J7.12 106.71,206.33 ; J7.12 106.71,204.22 ; J7.12 107.76,205.27 ; 105.65,207.81 J7.10 ; J7.10 106.71,206.76 ; J7.10 106.71,208.87 ; J7.10 107.76,207.81 ; JP1.50 302.51,83.78 ; JP1.50 302.51,81.67 ; JP1.50 303.57,82.72 ; JP1.50 301.46,82.72 ; J18.3 269.93,123.71 ; J18.3 268.86,124.78 ; J18.3 267.79,123.71 ; 280.75,243.37 J3.2 ; J3.2 282.96,244.44 ; J3.2 282.96,242.31 ; J3.2 285.17,243.37 ; 298.91,198.87 J12.31 ; J12.31 299.95,197.82 ; J12.31 299.95,199.91 ; J12.31 300.99,198.87 ; JP1.84 302.51,40.6 ; JP1.84 303.57,39.54 ; JP1.84 302.51,38.49 ; JP1.84 301.46,39.54 ; TP203.1 110.74,205.36 ; TP203.1 109.74,204.36 ; TP203.1 110.74,203.35 ; TP203.1 111.75,204.36 ; J12.6 303.53,231.89 ; J12.6 301.45,231.89 ; J12.6 302.49,232.93 ; J12.6 302.49,230.84 ; JP1.38 303.57,97.96 ; JP1.38 302.51,96.91 ; JP1.38 301.46,97.96 ; JP1.38 302.51,99.02 ; 301.46,120.82 JP1.20 ; JP1.20 303.57,120.82 ; JP1.20 302.51,121.88 ; JP1.20 302.51,119.77 ; 299.97,23.25 JP1.95 ; JP1.95 299.97,25.36 ; JP1.95 298.92,24.3 ; JP1.95 301.03,24.3 ; MOD1.K 72.23,227.36 ; MOD1.K 73.64,225.95 ; MOD1.K 70.82,225.95 ; MOD1.K 72.23,224.54 ; JP1.32 302.51,106.64 ; JP1.32 301.46,105.58 ; JP1.32 302.51,104.53 ; JP1.32 303.57,105.58 ; JP1.80 303.57,44.62 ; JP1.80 302.51,43.57 ; JP1.80 302.51,45.68 ; JP1.80 301.46,44.62 ; J12.49 300.99,176.01 ; J12.49 299.95,174.96 ; J12.49 299.95,177.05 ; J12.49 298.91,176.01 ; 57.93,224.78 MOD1.11 57.93,223.21 ; J7.8 107.76,210.35 ; J7.8 106.71,209.3 ; J7.8 106.71,211.41 ; J7.8 105.65,210.35 ; JP1.31 301.03,105.58 ; JP1.31 298.92,105.58 ; JP1.31 299.97,104.53 ; 299.97,112.15 JP1.25 ; JP1.25 301.03,113.2 ; JP1.25 298.92,113.2 ; 298.92,82.72 JP1.49 ; JP1.49 301.03,82.72 ; JP1.49 299.97,81.67 ; J12.5 300.99,231.89 ; J12.5 299.95,230.84 ; J12.5 299.95,232.93 ; J12.5 298.91,231.89 ; JP1.37 301.03,97.96 ; JP1.37 299.97,96.91 ; JP1.37 298.92,97.96 ; J12.48 302.49,179.59 ; J12.48 301.45,178.55 ; J12.48 302.49,177.5 ; J12.48 303.53,178.55 ; JP1.13 301.03,128.44 ; JP1.13 299.97,129.5 ; JP1.13 299.97,127.39 ; JP1.13 298.92,128.44 ; 298.92,19.22 JP1.99 ; JP1.99 299.97,20.28 ; JP1.99 301.03,19.22 ; JP1.99 299.97,18.17 ; J12.7 300.99,229.35 ; J12.7 298.91,229.35 ; J12.7 299.95,228.3 ; J12.7 299.95,230.39 ; J17.1 271.02,179.52 ; J17.1 271.02,177.38 ; J17.1 269.95,178.45 ; J17.1 272.08,178.45 ; 302.51,112.15 JP1.26 ; JP1.26 301.46,113.2 ; JP1.26 302.51,114.26 ; JP1.26 303.57,113.2 ; J12.26 303.53,206.49 ; J12.26 301.45,206.49 ; J12.26 302.49,205.44 ; J12.26 302.49,207.53 ; 15.21,234.24 J6.2 ; J6.2 14.06,235.4 ; J6.2 15.21,236.55 ; J6.2 16.37,235.4 ; 299.97,89.29 JP1.43 ; JP1.43 298.92,90.34 ; JP1.43 301.03,90.34 ; JP1.74 303.57,52.24 ; JP1.74 301.46,52.24 ; JP1.74 302.51,53.3 ; JP1.74 302.51,51.19 ; JP1.68 302.51,60.92 ; JP1.68 303.57,59.86 ; JP1.68 302.51,58.81 ; JP1.68 301.46,59.86 ; J12.50 302.49,177.05 ; J12.50 301.45,176.01 ; J12.50 303.53,176.01 ; J12.50 302.49,174.96 ; 301.46,24.3 JP1.96 ; JP1.96 302.51,23.25 ; JP1.96 302.51,25.36 ; JP1.96 303.57,24.3 ; 301.03,44.62 JP1.79 300.77,45.42 ; JP1.62 303.57,67.48 ; JP1.62 302.51,68.54 ; JP1.62 301.46,67.48 ; JP1.62 302.51,66.43 ; JP1.19 301.03,120.82 ; JP1.19 299.97,119.77 ; JP1.19 298.92,120.82 ; 265.29,84.11 TP129.1 ; TP129.1 267.3,84.11 ; TP129.1 266.29,83.11 ; TP129.1 266.29,85.12 ; 302.51,127.39 JP1.14 ; JP1.14 301.46,128.44 ; JP1.14 303.57,128.44 ; JP1.14 302.51,129.5 ; 5.54,20.45 TP51.1 ; TP51.1 5.54,22.46 ; TP51.1 4.53,21.45 ; TP51.1 6.54,21.45 ; 104.65,166.63 TP90.1 ; TP90.1 104.65,168.63 ; TP90.1 105.65,167.63 ; TP90.1 103.64,167.63 ; 267.72,206.05 TP61.1 ; TP61.1 266.71,207.05 ; TP61.1 267.72,208.05 ; TP61.1 268.72,207.05 ; 302.51,35.95 JP1.86 ; JP1.86 302.51,38.06 ; JP1.86 303.57,37 ; JP1.86 301.46,37 ; TP53.1 11.58,226.6 ; TP53.1 10.58,225.59 ; TP53.1 12.59,225.59 ; TP53.1 11.58,224.59 ; 98.3,188.69 J11.3 ; J11.3 97.23,189.75 ; J11.3 99.36,189.75 ; J11.3 98.3,190.82 ; JP1.91 301.03,29.38 ; JP1.91 299.97,30.44 ; JP1.91 298.92,29.38 ; JP1.91 299.97,28.33 ; 259.77,14.59 J1.5 260.5,13.86 ; 267.73,184.16 TP92.1 ; TP92.1 268.73,185.17 ; TP92.1 269.74,184.16 ; TP92.1 268.73,183.16 ; 301.03,59.86 JP1.67 298.92,59.86 ; J4.6 241.83,83.64 ; J4.6 242.89,82.59 ; J4.6 241.83,81.54 ; 298.92,136.06 JP1.7 ; JP1.7 299.97,135.01 ; JP1.7 301.03,136.06 ; 242.3,215.22 TP62.1 ; TP62.1 243.3,216.22 ; TP62.1 241.3,216.22 ; TP62.1 242.3,217.22 ; 106.71,214.38 J7.4 ; J7.4 105.65,215.43 ; J7.4 107.76,215.43 ; TP201.1 159.6,230.11 ; TP201.1 158.6,229.11 ; TP201.1 157.59,230.11 ; TP201.1 158.6,231.12 ; 302.51,18.17 JP1.100 ; JP1.100 303.57,19.22 ; JP1.100 302.51,20.28 ; JP1.100 301.46,19.22 ; J49.1 45.61,100.07 ; J49.1 43.5,100.07 ; J49.1 44.55,99.01 ; J49.1 44.55,101.12 ; JP1.44 303.57,90.34 ; JP1.44 302.51,91.4 ; JP1.44 302.51,89.29 ; JP1.44 301.46,90.34 ; 301.03,67.48 JP1.61 299.97,68.54 ; 302.49,197.82 J12.32 ; J12.32 303.53,198.87 ; J12.32 302.49,199.91 ; J12.32 301.45,198.87 ; 301.46,136.06 JP1.8 ; JP1.8 303.57,136.06 ; JP1.8 302.51,135.01 ; 301.03,75.1 JP1.55 300.77,74.31 ; 299.97,35.95 JP1.85 ; JP1.85 299.97,38.06 ; JP1.85 301.03,37 ; JP1.85 298.92,37 ; J10.2 61.85,192.09 ; J10.2 61.85,189.96 ; J10.2 62.92,191.02 ; J10.2 60.78,191.02 ; 301.03,52.24 JP1.73 298.92,52.24
  L04_GND2 w0.508: J12.44 302.49,184.67 ; J12.44 301.45,183.63 ; J12.44 303.53,183.63 ; J12.44 302.49,182.58 ; JP1.26 303.57,113.2 ; JP1.26 302.51,112.15 ; JP1.26 302.51,114.26 ; JP1.26 301.46,113.2 ; JP1.99 299.97,20.28 ; JP1.99 301.03,19.22 ; JP1.99 298.92,19.22 ; JP1.99 299.97,18.17 ; 299.97,135.01 JP1.7 ; JP1.7 299.97,137.12 ; JP1.7 298.92,136.06 ; JP1.7 301.03,136.06 ; 301.45,198.87 J12.32 ; J12.32 302.49,199.91 ; J12.32 302.49,197.82 ; J12.32 303.53,198.87 ; TP129.1 266.29,85.12 ; TP129.1 266.29,83.11 ; TP129.1 265.29,84.11 ; TP129.1 267.3,84.11 ; JP1.19 301.03,120.82 ; JP1.19 299.97,121.88 ; JP1.19 299.97,119.77 ; JP1.19 298.92,120.82 ; 302.49,213.06 J12.20 ; J12.20 301.45,214.11 ; J12.20 302.49,215.15 ; J12.20 303.53,214.11 ; JP1.91 299.97,30.44 ; JP1.91 299.97,28.33 ; JP1.91 301.03,29.38 ; JP1.91 298.92,29.38 ; TP90.1 104.65,168.63 ; TP90.1 105.65,167.63 ; TP90.1 104.65,166.63 ; TP90.1 103.64,167.63 ; 302.51,51.19 JP1.74 ; JP1.74 301.46,52.24 ; JP1.74 303.57,52.24 ; JP1.74 302.51,53.3 ; JP1.14 302.51,129.5 ; JP1.14 303.57,128.44 ; JP1.14 301.46,128.44 ; JP1.14 302.51,127.39 ; 299.97,140.09 JP1.3 ; JP1.3 299.97,142.2 ; JP1.3 298.92,141.14 ; JP1.3 301.03,141.14 ; J4.6 241.83,83.64 ; J4.6 240.78,82.59 ; J4.6 242.89,82.59 ; J4.6 241.83,81.54 ; JP1.96 302.51,25.36 ; JP1.96 302.51,23.25 ; JP1.96 303.57,24.3 ; JP1.96 301.46,24.3 ; 301.45,231.89 J12.6 ; J12.6 303.53,231.89 ; J12.6 302.49,230.84 ; J12.6 302.49,232.93 ; TP92.1 268.73,185.17 ; TP92.1 269.74,184.16 ; TP92.1 268.73,183.16 ; TP92.1 267.73,184.16 ; 298.92,52.24 JP1.73 ; JP1.73 299.97,51.19 ; JP1.73 301.03,52.24 ; JP1.73 299.97,53.3 ; J11.3 98.3,190.82 ; J11.3 98.3,188.69 ; J11.3 97.23,189.75 ; J11.3 99.36,189.75 ; 267.79,123.71 J18.3 ; J18.3 269.93,123.71 ; J18.3 268.86,124.78 ; J18.3 268.86,122.65 ; 14.06,235.4 J6.2 ; J6.2 16.37,235.4 ; J6.2 15.21,234.24 ; J6.2 15.21,236.55 ; J12.48 303.53,178.55 ; J12.48 302.49,177.5 ; J12.48 302.49,179.59 ; J12.48 301.45,178.55 ; 298.92,113.2 JP1.25 ; JP1.25 301.03,113.2 ; JP1.25 299.97,114.26 ; JP1.25 299.97,112.15 ; TP201.1 159.6,230.11 ; TP201.1 158.6,231.12 ; TP201.1 157.59,230.11 ; TP201.1 158.6,229.11 ; JP1.84 303.57,39.54 ; JP1.84 302.51,40.6 ; JP1.84 301.46,39.54 ; JP1.84 302.51,38.49 ; 105.65,210.35 J7.8 ; J7.8 106.71,211.41 ; J7.8 107.76,210.35 ; J7.8 106.71,209.3 ; 4.53,21.45 TP51.1 ; TP51.1 6.54,21.45 ; TP51.1 5.54,22.46 ; TP51.1 5.54,20.45 ; JP1.49 299.97,83.78 ; JP1.49 299.97,81.67 ; JP1.49 301.03,82.72 ; JP1.49 298.92,82.72 ; 298.92,90.34 JP1.43 ; JP1.43 299.97,89.29 ; JP1.43 299.97,91.4 ; JP1.43 301.03,90.34 ; JP1.68 302.51,60.92 ; JP1.68 301.46,59.86 ; JP1.68 303.57,59.86 ; JP1.68 302.51,58.81 ; 242.3,215.22 TP62.1 ; TP62.1 242.3,217.22 ; TP62.1 243.3,216.22 ; TP62.1 241.3,216.22 ; 299.97,58.81 JP1.67 ; JP1.67 298.92,59.86 ; JP1.67 301.03,59.86 ; JP1.67 299.97,60.92 ; 299.97,96.91 JP1.37 ; JP1.37 299.97,99.02 ; JP1.37 301.03,97.96 ; JP1.37 298.92,97.96 ; J12.49 300.99,176.01 ; J12.49 299.95,174.96 ; J12.49 298.91,176.01 ; J12.49 299.95,177.05 ; 57.93,224.78 MOD1.11 57.93,223.21 ; JP1.31 299.97,106.64 ; JP1.31 301.03,105.58 ; JP1.31 298.92,105.58 ; JP1.31 299.97,104.53 ; J7.10 106.71,208.87 ; J7.10 107.76,207.81 ; J7.10 105.65,207.81 ; J7.10 106.71,206.76 ; J12.7 300.99,229.35 ; J12.7 298.91,229.35 ; J12.7 299.95,228.3 ; J12.7 299.95,230.39 ; 109.87,201.94 TP204.1 ; TP204.1 110.87,202.95 ; TP204.1 111.87,201.94 ; TP204.1 110.87,200.94 ; 88.44,100.33 TP104.1 ; TP104.1 89.45,101.34 ; TP104.1 87.44,101.34 ; TP104.1 88.44,102.34 ; J12.31 300.99,198.87 ; J12.31 299.95,197.82 ; J12.31 299.95,199.91 ; J12.31 298.91,198.87 ; 302.49,228.3 J12.8 ; J12.8 301.45,229.35 ; J12.8 302.49,230.39 ; J12.8 303.53,229.35 ; J12.26 302.49,207.53 ; J12.26 302.49,205.44 ; J12.26 303.53,206.49 ; J12.26 301.45,206.49 ; TP61.1 267.72,208.05 ; TP61.1 267.72,206.05 ; TP61.1 266.71,207.05 ; TP61.1 268.72,207.05 ; JP1.38 303.57,97.96 ; JP1.38 302.51,96.91 ; JP1.38 302.51,99.02 ; JP1.38 301.46,97.96 ; 269.95,178.45 J17.1 ; J17.1 272.08,178.45 ; J17.1 271.02,177.38 ; J17.1 271.02,179.52 ; 299.95,215.6 J12.17 ; J12.17 299.95,217.69 ; J12.17 300.99,216.65 ; J12.17 298.91,216.65 ; J10.2 62.92,191.02 ; J10.2 61.85,189.96 ; J10.2 60.78,191.02 ; J10.2 61.85,192.09 ; TP53.1 12.59,225.59 ; TP53.1 11.58,224.59 ; TP53.1 10.58,225.59 ; TP53.1 11.58,226.6 ; 301.45,188.71 J12.40 ; J12.40 302.49,187.66 ; J12.40 302.49,189.75 ; J12.40 303.53,188.71 ; 10.63,108.45 P1.5 ; P1.5 11.68,107.39 ; P1.5 12.74,108.45 ; P1.5 11.68,109.5 ; 194.18,48.9 TP202.1 ; TP202.1 193.18,49.9 ; TP202.1 195.19,49.9 ; TP202.1 194.18,50.9 ; J3.2 282.96,244.44 ; J3.2 280.75,243.37 ; J3.2 282.96,242.31 ; J3.2 285.17,243.37 ; J49.1 45.61,100.07 ; J49.1 44.55,99.01 ; J49.1 43.5,100.07 ; J49.1 44.55,101.12 ; 298.92,24.3 JP1.95 ; JP1.95 299.97,23.25 ; JP1.95 301.03,24.3 ; JP1.95 299.97,25.36 ; JP1.55 301.03,75.1 ; JP1.55 299.97,74.05 ; JP1.55 298.92,75.1 ; JP1.55 299.97,76.16 ; JP1.80 302.51,45.68 ; JP1.80 301.46,44.62 ; JP1.80 302.51,43.57 ; JP1.80 303.57,44.62 ; JP1.8 303.57,136.06 ; JP1.8 302.51,135.01 ; JP1.8 302.51,137.12 ; JP1.8 301.46,136.06 ; J12.50 302.49,177.05 ; J12.50 303.53,176.01 ; J12.50 301.45,176.01 ; J12.50 302.49,174.96 ; 110.74,203.35 TP203.1 ; TP203.1 110.74,205.36 ; TP203.1 111.75,204.36 ; TP203.1 109.74,204.36 ; 302.51,104.53 JP1.32 ; JP1.32 302.51,106.64 ; JP1.32 301.46,105.58 ; JP1.32 303.57,105.58 ; JP1.1 299.97,144.74 ; JP1.1 298.92,143.68 ; JP1.1 301.03,143.68 ; JP1.1 299.97,142.63 ; JP1.86 303.57,37 ; JP1.86 302.51,35.95 ; JP1.86 302.51,38.06 ; JP1.86 301.46,37 ; 299.97,43.57 JP1.79 ; JP1.79 299.97,45.68 ; JP1.79 301.03,44.62 ; JP1.79 298.92,44.62 ; 301.46,120.82 JP1.20 ; JP1.20 303.57,120.82 ; JP1.20 302.51,119.77 ; JP1.20 302.51,121.88 ; JP1.44 303.57,90.34 ; JP1.44 301.46,90.34 ; JP1.44 302.51,89.29 ; JP1.44 302.51,91.4 ; 298.92,138.6 JP1.5 ; JP1.5 299.97,137.55 ; JP1.5 299.97,139.66 ; JP1.5 301.03,138.6 ; 302.51,81.67 JP1.50 ; JP1.50 302.51,83.78 ; JP1.50 301.46,82.72 ; JP1.50 303.57,82.72 ; J7.12 107.76,205.27 ; J7.12 105.65,205.27 ; J7.12 106.71,206.33 ; J7.12 106.71,204.22 ; JP1.61 301.03,67.48 ; JP1.61 298.92,67.48 ; JP1.61 299.97,66.43 ; JP1.61 299.97,68.54 ; 278.16,237.91 J3.3 ; J3.3 279.22,240.12 ; J3.3 278.16,242.33 ; J3.3 277.09,240.12 ; MOD1.K 72.23,227.36 ; MOD1.K 73.64,225.95 ; MOD1.K 72.23,224.54 ; MOD1.K 70.82,225.95 ; J12.43 300.99,183.63 ; J12.43 299.95,184.67 ; J12.43 299.95,182.58 ; J12.43 298.91,183.63 ; JP1.56 303.57,75.1 ; JP1.56 302.51,76.16 ; JP1.56 301.46,75.1 ; JP1.56 302.51,74.05 ; 260.5,13.86 J1.5 259.77,14.59 ; JP1.62 303.57,67.48 ; JP1.62 302.51,66.43 ; JP1.62 302.51,68.54 ; JP1.62 301.46,67.48 ; 93.09,190.97 J9.3 ; J9.3 92.02,192.04 ; J9.3 94.16,192.04 ; J9.3 93.09,193.11 ; 299.95,230.84 J12.5 ; J12.5 298.91,231.89 ; J12.5 299.95,232.93 ; J12.5 300.99,231.89 ; 299.97,127.39 JP1.13 ; JP1.13 298.92,128.44 ; JP1.13 301.03,128.44 ; JP1.13 299.97,129.5 ; J7.4 106.71,216.49 ; J7.4 107.76,215.43 ; J7.4 106.71,214.38 ; J7.4 105.65,215.43 ; 163.03,26.81 J31.1 ; J31.1 164.99,26.81 ; J31.1 164.01,25.83 ; J31.1 164.01,27.79 ; 299.97,35.95 JP1.85 ; JP1.85 299.97,38.06 ; JP1.85 298.92,37 ; JP1.85 301.03,37 ; 301.46,19.22 JP1.100 ; JP1.100 303.57,19.22 ; JP1.100 302.51,20.28 ; JP1.100 302.51,18.17
  L07_GND3 w0.508: 301.46,67.48 JP1.62 ; JP1.62 302.51,68.54 ; JP1.62 302.51,66.43 ; JP1.62 303.57,67.48 ; J12.31 299.95,199.91 ; J12.31 300.99,198.87 ; J12.31 298.91,198.87 ; J12.31 299.95,197.82 ; JP1.95 299.97,25.36 ; JP1.95 301.03,24.3 ; JP1.95 298.92,24.3 ; JP1.95 299.97,23.25 ; J3.3 279.22,240.12 ; J3.3 277.09,240.12 ; J3.3 278.16,242.33 ; J3.3 278.16,237.91 ; J7.12 106.71,206.33 ; J7.12 107.76,205.27 ; J7.12 105.65,205.27 ; J7.12 106.71,204.22 ; 298.91,183.63 J12.43 ; J12.43 299.95,182.58 ; J12.43 300.99,183.63 ; J12.43 299.95,184.67 ; 302.51,35.95 JP1.86 ; JP1.86 302.51,38.06 ; JP1.86 303.57,37 ; JP1.86 301.46,37 ; JP1.91 299.97,30.44 ; JP1.91 298.92,29.38 ; JP1.91 301.03,29.38 ; JP1.91 299.97,28.33 ; JP1.96 303.57,24.3 ; JP1.96 301.46,24.3 ; JP1.96 302.51,25.36 ; JP1.96 302.51,23.25 ; 44.55,99.01 J49.1 ; J49.1 43.5,100.07 ; J49.1 44.55,101.12 ; J49.1 45.61,100.07 ; TP201.1 159.6,230.11 ; TP201.1 157.59,230.11 ; TP201.1 158.6,229.11 ; TP201.1 158.6,231.12 ; 267.79,123.71 J18.3 ; J18.3 269.93,123.71 ; J18.3 268.86,122.65 ; J18.3 268.86,124.78 ; JP1.25 299.97,114.26 ; JP1.25 301.03,113.2 ; JP1.25 299.97,112.15 ; JP1.25 298.92,113.2 ; J12.20 303.53,214.11 ; J12.20 302.49,215.15 ; J12.20 301.45,214.11 ; J12.20 302.49,213.06 ; JP1.37 299.97,99.02 ; JP1.37 298.92,97.96 ; JP1.37 301.03,97.96 ; JP1.37 299.97,96.91 ; J11.3 99.36,189.75 ; J11.3 98.3,188.69 ; J11.3 97.23,189.75 ; J11.3 98.3,190.82 ; JP1.38 303.57,97.96 ; JP1.38 301.46,97.96 ; JP1.38 302.51,99.02 ; JP1.38 302.51,96.91 ; JP1.73 299.97,53.3 ; JP1.73 301.03,52.24 ; JP1.73 298.92,52.24 ; JP1.73 299.97,51.19 ; J12.44 302.49,184.67 ; J12.44 303.53,183.63 ; J12.44 302.49,182.58 ; J12.44 301.45,183.63 ; JP1.100 302.51,20.28 ; JP1.100 303.57,19.22 ; JP1.100 301.46,19.22 ; JP1.100 302.51,18.17 ; TP90.1 104.65,168.63 ; TP90.1 105.65,167.63 ; TP90.1 104.65,166.63 ; TP90.1 103.64,167.63 ; 163.03,26.81 J31.1 ; J31.1 164.01,27.79 ; J31.1 164.99,26.81 ; J31.1 164.01,25.83 ; JP1.31 301.03,105.58 ; JP1.31 299.97,106.64 ; JP1.31 298.92,105.58 ; JP1.31 299.97,104.53 ; P1.5 12.74,108.45 ; P1.5 11.68,109.5 ; P1.5 10.63,108.45 ; P1.5 11.68,107.39 ; 302.49,177.5 J12.48 ; J12.48 303.53,178.55 ; J12.48 301.45,178.55 ; J12.48 302.49,179.59 ; JP1.13 299.97,129.5 ; JP1.13 298.92,128.44 ; JP1.13 299.97,127.39 ; JP1.13 301.03,128.44 ; J12.6 303.53,231.89 ; J12.6 301.45,231.89 ; J12.6 302.49,232.93 ; J12.6 302.49,230.84 ; JP1.99 301.03,19.22 ; JP1.99 298.92,19.22 ; JP1.99 299.97,20.28 ; JP1.99 299.97,18.17 ; 302.51,119.77 JP1.20 ; JP1.20 302.51,121.88 ; JP1.20 301.46,120.82 ; JP1.20 303.57,120.82 ; JP1.3 299.97,142.2 ; JP1.3 299.97,140.09 ; JP1.3 301.03,141.14 ; JP1.3 298.92,141.14 ; 106.71,206.76 J7.10 ; J7.10 105.65,207.81 ; J7.10 107.76,207.81 ; J7.10 106.71,208.87 ; TP92.1 269.74,184.16 ; TP92.1 268.73,185.17 ; TP92.1 267.73,184.16 ; TP92.1 268.73,183.16 ; J12.50 302.49,177.05 ; J12.50 301.45,176.01 ; J12.50 303.53,176.01 ; J12.50 302.49,174.96 ; JP1.80 302.51,45.68 ; JP1.80 301.46,44.62 ; JP1.80 302.51,43.57 ; JP1.80 303.57,44.62 ; J9.3 93.09,193.11 ; J9.3 93.09,190.97 ; J9.3 92.02,192.04 ; J9.3 94.16,192.04 ; JP1.8 302.51,137.12 ; JP1.8 303.57,136.06 ; JP1.8 302.51,135.01 ; JP1.8 301.46,136.06 ; 302.49,228.3 J12.8 ; J12.8 301.45,229.35 ; J12.8 303.53,229.35 ; J12.8 302.49,230.39 ; JP1.67 299.97,60.92 ; JP1.67 298.92,59.86 ; JP1.67 299.97,58.81 ; JP1.67 301.03,59.86 ; JP1.74 302.51,53.3 ; JP1.74 303.57,52.24 ; JP1.74 302.51,51.19 ; JP1.74 301.46,52.24 ; 302.49,205.44 J12.26 ; J12.26 303.53,206.49 ; J12.26 302.49,207.53 ; J12.26 301.45,206.49 ; JP1.19 301.03,120.82 ; JP1.19 299.97,119.77 ; JP1.19 299.97,121.88 ; JP1.19 298.92,120.82 ; 301.46,39.54 JP1.84 ; JP1.84 302.51,40.6 ; JP1.84 303.57,39.54 ; JP1.84 302.51,38.49 ; JP1.5 299.97,139.66 ; JP1.5 298.92,138.6 ; JP1.5 299.97,137.55 ; JP1.5 301.03,138.6 ; 299.95,230.84 J12.5 ; J12.5 300.99,231.89 ; J12.5 298.91,231.89 ; J12.5 299.95,232.93 ; TP51.1 5.54,22.46 ; TP51.1 4.53,21.45 ; TP51.1 6.54,21.45 ; TP51.1 5.54,20.45 ; JP1.43 301.03,90.34 ; JP1.43 299.97,89.29 ; JP1.43 299.97,91.4 ; JP1.43 298.92,90.34 ; JP1.26 302.51,114.26 ; JP1.26 302.51,112.15 ; JP1.26 303.57,113.2 ; JP1.26 301.46,113.2 ; JP1.1 301.03,143.68 ; JP1.1 299.97,142.63 ; JP1.1 298.92,143.68 ; JP1.1 299.97,144.74 ; 302.51,89.29 JP1.44 ; JP1.44 302.51,91.4 ; JP1.44 301.46,90.34 ; JP1.44 303.57,90.34 ; 298.92,37 JP1.85 ; JP1.85 299.97,35.95 ; JP1.85 301.03,37 ; JP1.85 299.97,38.06 ; 240.78,82.59 J4.6 ; J4.6 241.83,81.54 ; J4.6 242.89,82.59 ; J4.6 241.83,83.64 ; 70.82,225.95 MOD1.K ; MOD1.K 73.64,225.95 ; MOD1.K 72.23,227.36 ; MOD1.K 72.23,224.54 ; TP204.1 110.87,202.95 ; TP204.1 111.87,201.94 ; TP204.1 109.87,201.94 ; TP204.1 110.87,200.94 ; 10.58,225.59 TP53.1 ; TP53.1 11.58,224.59 ; TP53.1 12.59,225.59 ; TP53.1 11.58,226.6 ; 57.93,223.21 MOD1.11 57.93,224.78 ; J17.1 271.02,179.52 ; J17.1 271.02,177.38 ; J17.1 269.95,178.45 ; J17.1 272.08,178.45 ; 301.45,188.71 J12.40 ; J12.40 302.49,187.66 ; J12.40 303.53,188.71 ; J12.40 302.49,189.75 ; 61.85,189.96 J10.2 ; J10.2 61.85,192.09 ; J10.2 60.78,191.02 ; J10.2 62.92,191.02 ; 265.29,84.11 TP129.1 ; TP129.1 266.29,83.11 ; TP129.1 267.3,84.11 ; TP129.1 266.29,85.12 ; 298.91,229.35 J12.7 ; J12.7 299.95,230.39 ; J12.7 299.95,228.3 ; J12.7 300.99,229.35 ; JP1.49 301.03,82.72 ; JP1.49 299.97,81.67 ; JP1.49 298.92,82.72 ; JP1.49 299.97,83.78 ; TP202.1 194.18,50.9 ; TP202.1 195.19,49.9 ; TP202.1 193.18,49.9 ; TP202.1 194.18,48.9 ; TP104.1 89.45,101.34 ; TP104.1 88.44,102.34 ; TP104.1 88.44,100.33 ; TP104.1 87.44,101.34 ; J12.49 300.99,176.01 ; J12.49 299.95,177.05 ; J12.49 299.95,174.96 ; J12.49 298.91,176.01 ; 260.5,13.86 J1.5 259.77,14.59 ; 302.51,127.39 JP1.14 ; JP1.14 302.51,129.5 ; JP1.14 301.46,128.44 ; JP1.14 303.57,128.44 ; 302.49,197.82 J12.32 ; J12.32 302.49,199.91 ; J12.32 303.53,198.87 ; J12.32 301.45,198.87 ; J6.2 16.37,235.4 ; J6.2 14.06,235.4 ; J6.2 15.21,234.24 ; J6.2 15.21,236.55 ; 299.95,215.6 J12.17 ; J12.17 300.99,216.65 ; J12.17 298.91,216.65 ; J12.17 299.95,217.69 ; JP1.56 303.57,75.1 ; JP1.56 301.46,75.1 ; JP1.56 302.51,74.05 ; JP1.56 302.51,76.16 ; JP1.68 303.57,59.86 ; JP1.68 302.51,58.81 ; JP1.68 302.51,60.92 ; JP1.68 301.46,59.86 ; 298.92,75.1 JP1.55 ; JP1.55 299.97,76.16 ; JP1.55 299.97,74.05 ; JP1.55 301.03,75.1 ; JP1.50 303.57,82.72 ; JP1.50 302.51,81.67 ; JP1.50 302.51,83.78 ; JP1.50 301.46,82.72 ; 280.75,243.37 J3.2 ; J3.2 285.17,243.37 ; J3.2 282.96,242.31 ; J3.2 282.96,244.44 ; JP1.7 301.03,136.06 ; JP1.7 298.92,136.06 ; JP1.7 299.97,137.12 ; JP1.7 299.97,135.01 ; 106.71,214.38 J7.4 ; J7.4 106.71,216.49 ; J7.4 107.76,215.43 ; J7.4 105.65,215.43 ; 298.92,67.48 JP1.61 ; JP1.61 299.97,66.43 ; JP1.61 301.03,67.48 ; JP1.61 299.97,68.54 ; 105.65,210.35 J7.8 ; J7.8 107.76,210.35 ; J7.8 106.71,211.41 ; J7.8 106.71,209.3 ; JP1.79 299.97,45.68 ; JP1.79 299.97,43.57 ; JP1.79 298.92,44.62 ; JP1.79 301.03,44.62 ; 266.71,207.05 TP61.1 ; TP61.1 268.72,207.05 ; TP61.1 267.72,206.05 ; TP61.1 267.72,208.05 ; TP203.1 111.75,204.36 ; TP203.1 110.74,203.35 ; TP203.1 109.74,204.36 ; TP203.1 110.74,205.36 ; JP1.32 302.51,106.64 ; JP1.32 301.46,105.58 ; JP1.32 302.51,104.53 ; JP1.32 303.57,105.58 ; TP62.1 242.3,217.22 ; TP62.1 242.3,215.22 ; TP62.1 243.3,216.22 ; TP62.1 241.3,216.22
  L08_SIG2 w0.508: JP1.31 301.03,105.58 ; JP1.31 298.92,105.58 ; JP1.31 299.97,106.64 ; JP1.31 299.97,104.53 ; 242.89,82.59 J4.6 241.83,81.54 ; 301.46,39.54 JP1.84 ; JP1.84 302.51,38.49 ; JP1.84 302.51,40.6 ; JP1.84 303.57,39.54 ; J12.48 302.49,179.59 ; J12.48 303.53,178.55 ; J12.48 301.45,178.55 ; J12.48 302.49,177.5 ; 299.97,58.81 JP1.67 ; JP1.67 298.92,59.86 ; JP1.67 301.03,59.86 ; JP1.67 299.97,60.92 ; 302.51,112.15 JP1.26 ; JP1.26 303.57,113.2 ; JP1.26 302.51,114.26 ; JP1.26 301.46,113.2 ; 298.91,231.89 J12.5 ; J12.5 299.95,232.93 ; J12.5 300.99,231.89 ; J12.5 299.95,230.84 ; 61.85,189.96 J10.2 ; J10.2 60.78,191.02 ; J10.2 62.92,191.02 ; JP1.38 302.51,99.02 ; JP1.38 303.57,97.96 ; JP1.38 301.46,97.96 ; JP1.38 302.51,96.91 ; 301.46,37 JP1.86 ; JP1.86 302.51,35.95 ; JP1.86 302.51,38.06 ; JP1.86 303.57,37 ; 301.45,214.11 J12.20 ; J12.20 302.49,213.06 ; J12.20 303.53,214.11 ; J12.20 302.49,215.15 ; 106.71,214.38 J7.4 ; J7.4 106.71,216.49 ; J7.4 105.65,215.43 ; J7.4 107.76,215.43 ; JP1.14 303.57,128.44 ; JP1.14 302.51,127.39 ; JP1.14 302.51,129.5 ; JP1.14 301.46,128.44 ; 105.65,210.35 J7.8 ; J7.8 106.71,209.3 ; J7.8 107.76,210.35 ; J7.8 106.71,211.41 ; 302.49,187.66 J12.40 ; J12.40 301.45,188.71 ; J12.40 302.49,189.75 ; J12.40 303.53,188.71 ; 298.92,136.06 JP1.7 ; JP1.7 301.03,136.06 ; JP1.7 299.97,135.01 ; J12.17 299.95,217.69 ; J12.17 298.91,216.65 ; J12.17 299.95,215.6 ; J12.17 300.99,216.65 ; J12.6 303.53,231.89 ; J12.6 302.49,230.84 ; J12.6 301.45,231.89 ; J12.6 302.49,232.93 ; TP92.1 269.74,184.16 ; TP92.1 268.73,185.17 ; TP92.1 268.73,183.16 ; TP92.1 267.73,184.16 ; 11.68,107.39 P1.5 ; P1.5 11.68,109.5 ; P1.5 10.63,108.45 ; P1.5 12.74,108.45 ; 298.91,198.87 J12.31 ; J12.31 299.95,197.82 ; J12.31 300.99,198.87 ; J12.31 299.95,199.91 ; 57.93,224.78 MOD1.11 57.93,223.21 ; 267.79,123.71 J18.3 ; J18.3 269.93,123.71 ; J18.3 268.86,122.65 ; J18.3 268.86,124.78 ; JP1.85 301.03,37 ; JP1.85 299.97,38.06 ; JP1.85 298.92,37 ; JP1.85 299.97,35.95 ; JP1.32 303.57,105.58 ; JP1.32 302.51,104.53 ; JP1.32 301.46,105.58 ; JP1.32 302.51,106.64 ; J31.1 164.99,26.81 ; J31.1 163.03,26.81 ; J31.1 164.01,25.83 ; J12.7 299.95,230.39 ; J12.7 298.91,229.35 ; J12.7 300.99,229.35 ; J12.7 299.95,228.3 ; 10.58,225.59 TP53.1 ; TP53.1 11.58,224.59 ; TP53.1 11.58,226.6 ; TP53.1 12.59,225.59 ; 301.46,59.86 JP1.68 ; JP1.68 302.51,58.81 ; JP1.68 303.57,59.86 ; JP1.68 302.51,60.92 ; JP1.50 302.51,83.78 ; JP1.50 301.46,82.72 ; JP1.50 303.57,82.72 ; JP1.50 302.51,81.67 ; J12.26 303.53,206.49 ; J12.26 301.45,206.49 ; J12.26 302.49,207.53 ; J12.26 302.49,205.44 ; J49.1 45.61,100.07 ; J49.1 44.55,99.01 ; J49.1 43.5,100.07 ; J49.1 44.55,101.12 ; 110.74,203.35 TP203.1 ; TP203.1 109.74,204.36 ; TP203.1 111.75,204.36 ; TP203.1 110.74,205.36 ; TP201.1 159.6,230.11 ; TP201.1 157.59,230.11 ; TP201.1 158.6,229.11 ; TP201.1 158.6,231.12 ; TP61.1 268.72,207.05 ; TP61.1 267.72,206.05 ; TP61.1 266.71,207.05 ; TP61.1 267.72,208.05 ; J12.8 303.53,229.35 ; J12.8 302.49,228.3 ; J12.8 302.49,230.39 ; J12.8 301.45,229.35 ; 266.29,83.11 TP129.1 ; TP129.1 265.29,84.11 ; TP129.1 266.29,85.12 ; TP129.1 267.3,84.11 ; 301.45,198.87 J12.32 ; J12.32 302.49,197.82 ; J12.32 303.53,198.87 ; J12.32 302.49,199.91 ; JP1.43 301.03,90.34 ; JP1.43 298.92,90.34 ; JP1.43 299.97,89.29 ; JP1.43 299.97,91.4 ; 301.46,136.06 JP1.8 ; JP1.8 302.51,135.01 ; JP1.8 303.57,136.06 ; JP1.80 302.51,45.68 ; JP1.80 303.57,44.62 ; JP1.80 302.51,43.57 ; JP1.80 301.46,44.62 ; 299.97,23.25 JP1.95 ; JP1.95 301.03,24.3 ; JP1.95 298.92,24.3 ; JP1.61 301.03,67.48 ; JP1.61 298.92,67.48 ; JP1.61 299.97,66.43 ; JP1.61 299.97,68.54 ; JP1.56 302.51,76.16 ; JP1.56 301.46,75.1 ; JP1.56 302.51,74.05 ; JP1.56 303.57,75.1 ; J12.50 303.53,176.01 ; J12.50 301.45,176.01 ; J12.50 302.49,177.05 ; J12.50 302.49,174.96 ; J6.2 15.21,236.55 ; J6.2 14.06,235.4 ; J6.2 15.21,234.24 ; J6.2 16.37,235.4 ; JP1.73 299.97,53.3 ; JP1.73 299.97,51.19 ; JP1.73 301.03,52.24 ; JP1.73 298.92,52.24 ; JP1.79 299.97,45.68 ; JP1.79 301.03,44.62 ; JP1.79 299.97,43.57 ; JP1.79 298.92,44.62 ; 302.51,18.17 JP1.100 ; JP1.100 303.57,19.22 ; JP1.100 301.46,19.22 ; JP1.100 302.51,20.28 ; 298.92,113.2 JP1.25 ; JP1.25 301.03,113.2 ; JP1.25 299.97,112.15 ; JP1.25 299.97,114.26 ; JP1.62 303.57,67.48 ; JP1.62 302.51,66.43 ; JP1.62 301.46,67.48 ; JP1.62 302.51,68.54 ; JP1.37 299.97,99.02 ; JP1.37 299.97,96.91 ; JP1.37 298.92,97.96 ; JP1.37 301.03,97.96 ; 302.49,182.58 J12.44 ; J12.44 303.53,183.63 ; J12.44 302.49,184.67 ; J12.44 301.45,183.63 ; 87.44,101.34 TP104.1 ; TP104.1 88.44,102.34 ; TP104.1 89.45,101.34 ; TP104.1 88.44,100.33 ; 280.75,243.37 J3.2 ; J3.2 282.96,244.44 ; J3.2 282.96,242.31 ; J3.2 285.17,243.37 ; JP1.13 301.03,128.44 ; JP1.13 299.97,127.39 ; JP1.13 298.92,128.44 ; JP1.13 299.97,129.5 ; 277.09,240.12 J3.3 ; J3.3 278.16,237.91 ; J3.3 278.16,242.33 ; J3.3 279.22,240.12 ; 298.91,183.63 J12.43 ; J12.43 299.95,182.58 ; J12.43 300.99,183.63 ; J12.43 299.95,184.67 ; 302.51,23.25 JP1.96 ; JP1.96 302.51,25.36 ; JP1.96 303.57,24.3 ; JP1.96 301.46,24.3 ; TP90.1 104.65,168.63 ; TP90.1 105.65,167.63 ; TP90.1 103.64,167.63 ; TP90.1 104.65,166.63 ; J17.1 272.08,178.45 ; J17.1 269.95,178.45 ; J17.1 271.02,179.52 ; J17.1 271.02,177.38 ; 299.95,174.96 J12.49 ; J12.49 299.95,177.05 ; J12.49 300.99,176.01 ; J12.49 298.91,176.01 ; 106.71,204.22 J7.12 ; J7.12 105.65,205.27 ; J7.12 106.71,206.33 ; J7.12 107.76,205.27 ; TP202.1 194.18,50.9 ; TP202.1 194.18,48.9 ; TP202.1 195.19,49.9 ; TP202.1 193.18,49.9 ; TP62.1 243.3,216.22 ; TP62.1 241.3,216.22 ; TP62.1 242.3,215.22 ; TP62.1 242.3,217.22 ; 93.09,193.11 J9.3 92.02,192.04 ; 299.97,28.33 JP1.91 ; JP1.91 301.03,29.38 ; JP1.91 298.92,29.38 ; 301.46,52.24 JP1.74 ; JP1.74 302.51,51.19 ; JP1.74 303.57,52.24 ; JP1.74 302.51,53.3 ; 4.53,21.45 TP51.1 ; TP51.1 6.54,21.45 ; TP51.1 5.54,20.45 ; TP51.1 5.54,22.46 ; 97.23,189.75 J11.3 ; J11.3 99.36,189.75 ; J11.3 98.3,188.69 ; J11.3 98.3,190.82 ; 301.46,120.82 JP1.20 ; JP1.20 303.57,120.82 ; JP1.20 302.51,121.88 ; JP1.20 302.51,119.77 ; JP1.44 303.57,90.34 ; JP1.44 302.51,89.29 ; JP1.44 301.46,90.34 ; JP1.44 302.51,91.4 ; J7.10 106.71,208.87 ; J7.10 106.71,206.76 ; J7.10 105.65,207.81 ; J7.10 107.76,207.81 ; 299.97,74.05 JP1.55 ; JP1.55 299.97,76.16 ; JP1.55 298.92,75.1 ; JP1.55 301.03,75.1 ; 72.23,224.54 MOD1.K ; MOD1.K 73.64,225.95 ; MOD1.K 72.23,227.36 ; MOD1.K 70.82,225.95 ; 298.92,19.22 JP1.99 ; JP1.99 299.97,20.28 ; JP1.99 301.03,19.22 ; JP1.99 299.97,18.17 ; JP1.49 301.03,82.72 ; JP1.49 299.97,83.78 ; JP1.49 299.97,81.67 ; JP1.49 298.92,82.72 ; TP204.1 111.87,201.94 ; TP204.1 109.87,201.94 ; TP204.1 110.87,200.94 ; TP204.1 110.87,202.95 ; JP1.19 299.97,121.88 ; JP1.19 298.92,120.82 ; JP1.19 301.03,120.82 ; JP1.19 299.97,119.77 ; 260.5,13.86 J1.5 259.77,14.59
  L09_GND4 w0.508: 298.92,29.38 JP1.91 ; JP1.91 299.97,30.44 ; JP1.91 299.97,28.33 ; JP1.91 301.03,29.38 ; 301.46,67.48 JP1.62 ; JP1.62 303.57,67.48 ; JP1.62 302.51,68.54 ; JP1.62 302.51,66.43 ; 97.23,189.75 J11.3 ; J11.3 98.3,190.82 ; J11.3 98.3,188.69 ; J11.3 99.36,189.75 ; JP1.19 299.97,121.88 ; JP1.19 301.03,120.82 ; JP1.19 299.97,119.77 ; JP1.19 298.92,120.82 ; 109.74,204.36 TP203.1 ; TP203.1 111.75,204.36 ; TP203.1 110.74,203.35 ; TP203.1 110.74,205.36 ; 302.51,96.91 JP1.38 ; JP1.38 303.57,97.96 ; JP1.38 301.46,97.96 ; JP1.38 302.51,99.02 ; JP1.80 302.51,45.68 ; JP1.80 302.51,43.57 ; JP1.80 303.57,44.62 ; JP1.80 301.46,44.62 ; 302.49,230.84 J12.6 ; J12.6 302.49,232.93 ; J12.6 301.45,231.89 ; J12.6 303.53,231.89 ; 267.79,123.71 J18.3 ; J18.3 268.86,122.65 ; J18.3 268.86,124.78 ; J18.3 269.93,123.71 ; JP1.3 301.03,141.14 ; JP1.3 299.97,142.2 ; JP1.3 299.97,140.09 ; JP1.3 298.92,141.14 ; J9.3 93.09,193.11 ; J9.3 92.02,192.04 ; J9.3 93.09,190.97 ; J9.3 94.16,192.04 ; J12.43 299.95,184.67 ; J12.43 299.95,182.58 ; J12.43 300.99,183.63 ; J12.43 298.91,183.63 ; 103.64,167.63 TP90.1 ; TP90.1 105.65,167.63 ; TP90.1 104.65,166.63 ; TP90.1 104.65,168.63 ; J7.12 106.71,206.33 ; J7.12 107.76,205.27 ; J7.12 105.65,205.27 ; J7.12 106.71,204.22 ; 299.95,230.84 J12.5 ; J12.5 298.91,231.89 ; J12.5 300.99,231.89 ; J12.5 299.95,232.93 ; 302.49,205.44 J12.26 ; J12.26 302.49,207.53 ; J12.26 301.45,206.49 ; J12.26 303.53,206.49 ; J7.8 106.71,211.41 ; J7.8 105.65,210.35 ; J7.8 106.71,209.3 ; J7.8 107.76,210.35 ; 301.46,37 JP1.86 ; JP1.86 302.51,38.06 ; JP1.86 303.57,37 ; JP1.86 302.51,35.95 ; J12.20 302.49,215.15 ; J12.20 302.49,213.06 ; J12.20 303.53,214.11 ; J12.20 301.45,214.11 ; J12.8 303.53,229.35 ; J12.8 302.49,228.3 ; J12.8 301.45,229.35 ; J12.8 302.49,230.39 ; 4.53,21.45 TP51.1 ; TP51.1 6.54,21.45 ; TP51.1 5.54,22.46 ; TP51.1 5.54,20.45 ; J12.32 302.49,199.91 ; J12.32 302.49,197.82 ; J12.32 303.53,198.87 ; J12.32 301.45,198.87 ; 301.46,82.72 JP1.50 ; JP1.50 303.57,82.72 ; JP1.50 302.51,81.67 ; JP1.50 302.51,83.78 ; TP104.1 89.45,101.34 ; TP104.1 88.44,100.33 ; TP104.1 87.44,101.34 ; TP104.1 88.44,102.34 ; 260.5,13.86 J1.5 259.77,14.59 ; 265.29,84.11 TP129.1 ; TP129.1 267.3,84.11 ; TP129.1 266.29,85.12 ; TP129.1 266.29,83.11 ; JP1.74 303.57,52.24 ; JP1.74 302.51,53.3 ; JP1.74 301.46,52.24 ; JP1.74 302.51,51.19 ; JP1.79 301.03,44.62 ; JP1.79 299.97,45.68 ; JP1.79 299.97,43.57 ; JP1.79 298.92,44.62 ; JP1.96 302.51,25.36 ; JP1.96 301.46,24.3 ; JP1.96 303.57,24.3 ; JP1.96 302.51,23.25 ; 299.97,112.15 JP1.25 ; JP1.25 301.03,113.2 ; JP1.25 298.92,113.2 ; JP1.25 299.97,114.26 ; 301.46,90.34 JP1.44 ; JP1.44 302.51,89.29 ; JP1.44 303.57,90.34 ; JP1.44 302.51,91.4 ; JP1.20 303.57,120.82 ; JP1.20 302.51,121.88 ; JP1.20 301.46,120.82 ; JP1.20 302.51,119.77 ; 267.72,206.05 TP61.1 ; TP61.1 266.71,207.05 ; TP61.1 267.72,208.05 ; TP61.1 268.72,207.05 ; J12.40 303.53,188.71 ; J12.40 302.49,187.66 ; J12.40 302.49,189.75 ; J12.40 301.45,188.71 ; J31.1 164.99,26.81 ; J31.1 163.03,26.81 ; J31.1 164.01,25.83 ; J31.1 164.01,27.79 ; JP1.73 301.03,52.24 ; JP1.73 299.97,53.3 ; JP1.73 299.97,51.19 ; JP1.73 298.92,52.24 ; 105.65,207.81 J7.10 ; J7.10 106.71,206.76 ; J7.10 107.76,207.81 ; J7.10 106.71,208.87 ; 242.3,215.22 TP62.1 ; TP62.1 242.3,217.22 ; TP62.1 243.3,216.22 ; TP62.1 241.3,216.22 ; 301.46,113.2 JP1.26 ; JP1.26 302.51,114.26 ; JP1.26 302.51,112.15 ; JP1.26 303.57,113.2 ; 240.78,82.59 J4.6 ; J4.6 242.89,82.59 ; J4.6 241.83,83.64 ; J4.6 241.83,81.54 ; J7.4 106.71,216.49 ; J7.4 105.65,215.43 ; J7.4 106.71,214.38 ; J7.4 107.76,215.43 ; 280.75,243.37 J3.2 ; J3.2 285.17,243.37 ; J3.2 282.96,244.44 ; J3.2 282.96,242.31 ; 299.97,23.25 JP1.95 ; JP1.95 301.03,24.3 ; JP1.95 298.92,24.3 ; JP1.95 299.97,25.36 ; J12.48 302.49,179.59 ; J12.48 302.49,177.5 ; J12.48 301.45,178.55 ; J12.48 303.53,178.55 ; JP1.49 299.97,83.78 ; JP1.49 298.92,82.72 ; JP1.49 301.03,82.72 ; JP1.49 299.97,81.67 ; 299.95,215.6 J12.17 ; J12.17 298.91,216.65 ; J12.17 299.95,217.69 ; J12.17 300.99,216.65 ; 301.46,75.1 JP1.56 ; JP1.56 302.51,74.05 ; JP1.56 302.51,76.16 ; JP1.56 303.57,75.1 ; 298.92,128.44 JP1.13 ; JP1.13 301.03,128.44 ; JP1.13 299.97,127.39 ; JP1.13 299.97,129.5 ; 44.55,99.01 J49.1 ; J49.1 43.5,100.07 ; J49.1 45.61,100.07 ; J49.1 44.55,101.12 ; JP1.85 301.03,37 ; JP1.85 299.97,35.95 ; JP1.85 299.97,38.06 ; JP1.85 298.92,37 ; JP1.7 301.03,136.06 ; JP1.7 299.97,137.12 ; JP1.7 298.92,136.06 ; JP1.7 299.97,135.01 ; 298.92,75.1 JP1.55 ; JP1.55 299.97,76.16 ; JP1.55 301.03,75.1 ; JP1.55 299.97,74.05 ; 60.78,191.02 J10.2 ; J10.2 61.85,189.96 ; J10.2 62.92,191.02 ; J10.2 61.85,192.09 ; TP202.1 195.19,49.9 ; TP202.1 194.18,50.9 ; TP202.1 194.18,48.9 ; TP202.1 193.18,49.9 ; 301.45,183.63 J12.44 ; J12.44 303.53,183.63 ; J12.44 302.49,184.67 ; J12.44 302.49,182.58 ; 299.97,66.43 JP1.61 ; JP1.61 299.97,68.54 ; JP1.61 298.92,67.48 ; JP1.61 301.03,67.48 ; 271.02,177.38 J17.1 ; J17.1 272.08,178.45 ; J17.1 271.02,179.52 ; J17.1 269.95,178.45 ; 299.95,228.3 J12.7 ; J12.7 298.91,229.35 ; J12.7 299.95,230.39 ; J12.7 300.99,229.35 ; 299.97,104.53 JP1.31 ; JP1.31 301.03,105.58 ; JP1.31 298.92,105.58 ; JP1.31 299.97,106.64 ; JP1.99 299.97,20.28 ; JP1.99 301.03,19.22 ; JP1.99 299.97,18.17 ; JP1.99 298.92,19.22 ; 298.92,59.86 JP1.67 ; JP1.67 299.97,60.92 ; JP1.67 299.97,58.81 ; JP1.67 301.03,59.86 ; JP1.68 303.57,59.86 ; JP1.68 302.51,58.81 ; JP1.68 302.51,60.92 ; JP1.68 301.46,59.86 ; 298.92,90.34 JP1.43 ; JP1.43 299.97,89.29 ; JP1.43 301.03,90.34 ; JP1.43 299.97,91.4 ; 72.23,224.54 MOD1.K ; MOD1.K 70.82,225.95 ; MOD1.K 73.64,225.95 ; MOD1.K 72.23,227.36 ; P1.5 11.68,109.5 ; P1.5 12.74,108.45 ; P1.5 11.68,107.39 ; P1.5 10.63,108.45 ; 268.73,183.16 TP92.1 ; TP92.1 269.74,184.16 ; TP92.1 267.73,184.16 ; TP92.1 268.73,185.17 ; TP204.1 111.87,201.94 ; TP204.1 110.87,202.95 ; TP204.1 110.87,200.94 ; TP204.1 109.87,201.94 ; 157.59,230.11 TP201.1 ; TP201.1 158.6,229.11 ; TP201.1 158.6,231.12 ; TP201.1 159.6,230.11 ; JP1.1 299.97,144.74 ; JP1.1 299.97,142.63 ; JP1.1 301.03,143.68 ; JP1.1 298.92,143.68 ; 278.16,237.91 J3.3 ; J3.3 277.09,240.12 ; J3.3 279.22,240.12 ; J3.3 278.16,242.33 ; 14.06,235.4 J6.2 ; J6.2 15.21,234.24 ; J6.2 15.21,236.55 ; J6.2 16.37,235.4 ; JP1.100 303.57,19.22 ; JP1.100 302.51,18.17 ; JP1.100 302.51,20.28 ; JP1.100 301.46,19.22 ; 298.92,138.6 JP1.5 ; JP1.5 299.97,139.66 ; JP1.5 301.03,138.6 ; JP1.5 299.97,137.55 ; 57.93,224.78 MOD1.11 57.93,223.21 ; JP1.8 303.57,136.06 ; JP1.8 302.51,137.12 ; JP1.8 302.51,135.01 ; JP1.8 301.46,136.06 ; 301.46,128.44 JP1.14 ; JP1.14 302.51,127.39 ; JP1.14 303.57,128.44 ; JP1.14 302.51,129.5 ; 301.46,39.54 JP1.84 ; JP1.84 303.57,39.54 ; JP1.84 302.51,40.6 ; JP1.84 302.51,38.49 ; 298.91,176.01 J12.49 ; J12.49 299.95,174.96 ; J12.49 299.95,177.05 ; J12.49 300.99,176.01 ; JP1.32 303.57,105.58 ; JP1.32 302.51,106.64 ; JP1.32 302.51,104.53 ; JP1.32 301.46,105.58 ; JP1.37 301.03,97.96 ; JP1.37 298.92,97.96 ; JP1.37 299.97,96.91 ; JP1.37 299.97,99.02 ; 301.45,176.01 J12.50 ; J12.50 303.53,176.01 ; J12.50 302.49,174.96 ; J12.50 302.49,177.05 ; TP53.1 12.59,225.59 ; TP53.1 11.58,226.6 ; TP53.1 11.58,224.59 ; TP53.1 10.58,225.59 ; 298.91,198.87 J12.31 ; J12.31 300.99,198.87 ; J12.31 299.95,199.91 ; J12.31 299.95,197.82
  BOTTOM w0.102: R719.2 177.23,125.41 178.41,125.41 v1(178.81,125.01) ; C393.1 242.17,50.87 242.22,50.92 ; 179.96,127.95 179.88,127.88 179.45,127.88 178.99,127.41 v1(178.81,127.41) 179.21,127.01 179.83,127.01 179.99,127.17 179.99,127.57 179.96,127.6 179.96,127.95 ; 179.96,127.95 179.98,127.98
  BOTTOM w0.127: C624.1 173.55,113.35 v1(174.01,113.81) ; v1(178.01,119.41) 178.4,119.81 180.25,119.81 180.37,119.7 ; C623.1 170.24,112.67 170.41,112.84 170.41,113.41 v1(170.01,113.81) ; C216.2 168.49,118.85 168.83,119.19 168.99,119.19 v1(169.21,119.41) ; v1(178.81,123.41) 179.2,123.02 180.2,123.02 180.34,123.16 C252.1
  BOTTOM w0.152: U149.6 v2(283.08,214.12) ; v1(170.01,117.01) 170.56,116.46 C195.2 ; v1(171.61,113.81) 171.61,114.3 C200.2 171.93,114.61 v1(172.41,114.61) 172.71,114.92 172.9,114.92 C260.1 ; C212.2 168.8,118.21 168.67,118.21 168.58,118.3 168.58,118.6 C216.2 ; C572.2 176.06,122.97 v1(176.41,122.61) 176.02,122.22 C587.1 ; C744.2 232.61,233.75 v2(232.92,233.44) ; C592.2 C594.2 ; v2(44.12,112.12) 44.07,112.07 C663.2 ; C631.2 v1(178.01,113.01) ; C417.2 v2(249.11,47.17)
  BOTTOM w0.178: U66.3 178.34,95.04 v2(178.44,95.14)
  BOTTOM w0.203: v1(174.01,118.61) 174.01,118.02 C193.2 ; U87.36 118.75,128.9 118.72,128.94 118.72,129.7 v2(118.75,129.73) ; v2(118.75,106.77) 118.53,106.99 118.53,107.5 118.74,107.71 118.75,107.71 U87.13 ; U87.25 v2(113.25,129.73) ; v1(172.41,120.21) 172.73,120.54 172.73,120.95 C188.2 ; v1(174.01,117.01) 174.01,116.67 C628.2 ; C263.2 171.31,121.01 v1(170.81,121.01) ; U87.48 v2(124.75,129.16)
  BOTTOM w0.254: C600.2 197.54,108.22 v2(197.97,107.79) ; v2(203.43,134.23) 203.67,133.99 C796.2 203.67,132.82 v2(203.33,132.48) ; C46.1 v2(246.51,84.85) ; v2(131.27,24.5) 130.94,24.82 130.9,24.82 129.62,26.11 C703.1 ; C486.1 214.66,78.86 v2(214.73,78.78) ; C589.2 145.27,120.27 144.86,119.85 143.2,119.85 142.45,120.61 v1(142.45,121.09) ; U37.8 223.81,76.68 v1(224.05,76.93) ; v2(133.73,228.61) 134.9,228.61 ; 134.9,228.61 134.92,228.59 D5.2 134.54,227.73 v2(133.73,227.73) ; 134.9,228.61 134.9,229.2 134.59,229.5 v2(133.73,229.5) ; C333.2 v2(171.48,43.65) ; v2(193.88,106.59) C564.2 C567.2 C553.2 ; C545.2 254.87,138.63 v2(254.58,138.93) ; C583.2 140.84,121.91 v2(141.5,122.57) ; R717.1 212.87,89.18 v2(212.85,89.17) ; U94.8 U94.3 168.86,33.14 169.57,33.14 169.57,33.14 v2(169.6,33.16) ; C483.1 185.93,197.26 v2(186.61,196.59) ; v2(92.6,198.66) 92.46,198.8 R652.2 ; v2(201.17,148.35) 201.13,148.31 201.13,147.01 U136.9 ; v2(174.01,86.63) 174.01,85.61 C287.1 ; v2(203.67,154.31) 203.67,154.35 203.06,154.95 R911.1 ; C570.2 135.37,126 134.87,126 134.58,126.29 134.58,127.61 134.76,127.79 v1(134.76,128.23) ; C401.1 236.73,38.39 v2(236.75,38.37) ; v1(176.41,114.61) 176.41,115.13 C215.2 ; C265.2 193.69,97.41 v2(193.85,97.58) ; v1(170.81,119.41) 171.56,118.66 C194.2 ; v1(169.21,121.01) 168.75,120.55 C576.2 ; C83.2 v2(180.87,208.63) ; v2(174.62,139.28) 173.56,139.28 173.33,139.05 C174.1 C180.2 ; v1(74.43,194.75) 74.48,194.8 C102.2 ; v1(175.61,117.01) 175.61,117.85 C196.2 ; C304.2 108.44,18.82 v2(108.08,18.46) ; C529.2 C528.2 ; C824.2 v2(273.6,211.09) ; U136.8 201.12,151.34 v2(201.13,151.33) ; v1(136.45,143.46) 136.45,141.32 136.67,141.1 R712.1 C523.2 ; C615.2 172.17,110.16 171.72,110.61 v1(171.61,110.61) ; R502.1 v2(194.69,156.99) ; v2(201.04,77.99) 201.29,77.74 C656.2 ; U111.5 v2(239.06,28.79) ; v1(134.76,143.47) 134.76,142.99 134.62,142.85 134.62,141.37 134.76,141.22 C530.2 ; C247.2 172.24,141.13 C536.1 171.79,141.15 170.26,142.69 168.58,142.69 v2(168.27,142.99) ; U90.8 U90.3
  BOTTOM w0.305: C475.2 141.22,172.21 141.48,172.47 ; C85.1 C395.1 ; v1(143.25,151.57) 143.85,152.18 C517.2 ; C404.2 261.49,219.75 261.85,220.11 v2(262.23,220.11) ; C495.2 138.41,165.2 v1(139.25,165.2) 140.34,164.11 140.85,164.11 141.36,163.61 C501.2 ; R827.2 293.62,56.16 293.62,55.54 v2(293.82,55.34) ; 141.35,157.11 141.49,156.97 C506.2 ; 141.35,157.11 141.35,158.61 v1(140.89,159.07) ; 141.35,157.11 141.21,156.97 C507.2 ; R718.1 C570.2 ; v1(140.06,182.07) 138,182.07 C444.2 ; C367.2 v2(289.53,99.94) ; R647.2 264.16,218.98 263.88,219.26 v2(263.88,220.36) ; C251.2 182.37,96.38 182.37,95.77 182.65,95.49 184.18,95.49 184.91,94.75 C267.2 187.86,93.49 v2(188.85,93.49) ; v1(134.84,182.89) 134.48,183.26 C445.2 ; v2(254.86,48.07) C66.2 C64.2 ; v1(142.45,151.57) 142.45,152.35 C511.2 ; C386.2 256.78,98.06 257.01,97.83 v2(257.01,96.41) ; C176.2 175.89,129.83 v1(177.21,131.15) ; v1(133.08,144.16) 133.08,143.14 133.22,143 C531.2 ; 136.45,172.14 136.02,171.7 C477.2 ; 136.45,172.14 136.52,172.21 R693.1 ; 136.45,172.14 v1(136.45,173.94) ; C580.2 132.73,122.08 132.59,121.93 132.59,121.93 132.55,121.9 v1(132.55,121.39) ; v2(123.46,230.76) 123.88,231.18 124.58,231.18 C387.1 ; v1(132.55,182.35) 131.48,182.35 130.93,182.91 C448.2 ; R653.1 226.17,43.5 225.54,42.86 224.55,42.86 v2(223.91,43.5) ; C584.2 138.58,123.73 137.54,122.69 C581.2 136.78,122.58 136.48,122.28 v1(136.48,121.92) ; v1(133.08,113.68) 132.83,113.43 132.46,113.43 132.07,113.03 C607.2 ; v1(140.06,166.83) 140.12,166.77 140.72,166.77 140.97,167.02 140.97,169.05 140.7,169.32 C489.2 ; v1(140.86,175.65) 139.85,175.65 C462.2 ; C619.1 177.84,121.18 v1(178.01,121.01) ; v2(223.91,45.28) 224.55,44.64 225.54,44.64 226.17,45.28 R651.1 ; C512.2 139.61,149.61 v1(139.25,149.96) 138.41,149.96 C516.2 ; R642.1 226.27,49.96 225.65,49.34 224.55,49.34 v2(223.91,49.98) ; 141.48,172.47 141.43,172.52 141.43,173.72 141.48,173.77 v1(141.48,174.37) ; 141.48,172.47 141.73,172.21 C474.2 ; C473.1 182.48,199.11 v2(182.74,198.84) ; C443.2 139.86,179.83 v1(139.25,180.44) 138.41,180.44 C449.2 ; v1(133.08,159.4) 133.08,158.4 133.24,158.24 C509.2 ; C441.2 103.27,185.3 102.61,185.3 v2(102.23,184.93) ; v2(62.23,172.86) 63.01,172.08 R312.1 ; C302.2 137.72,64.12 137.52,64.33 137.52,64.78 v1(137.65,64.92) ; C606.2 134.75,109.47 134.49,109.73 134.49,112.22 134.76,112.49 v1(134.76,112.99) ; C70.2 74.79,197.11 v1(75.41,197.73) ; C502.2 137.17,161.05 138.13,161.05 138.63,160.54 138.63,159.88 v1(139.01,159.5) ; v2(223.91,41.98) 224.55,41.34 225.54,41.34 226.17,41.98 R654.1 ; v1(170.01,115.41) 169.51,114.91 169.51,114.62 C253.1 168.53,115.16 C246.1 ; v2(194.44,245.25) 194.19,245.49 C362.2 ; R677.1 48.26,180.48 v2(48.13,180.61) ; C513.2 136.48,153.12 v1(136.48,152.4) ; C568.2 140.09,129.93 v1(140.86,129.93) ; 139.25,130.73 139.25,130.01 138.42,129.17 C559.2 ; C297.2 151.14,64.42 v1(151.85,63.71) ; C582.2 144.14,122.18 144.14,121.3 143.93,121.09 v1(143.25,121.09) ; C412.2 253.74,47.04 253.52,47.26 v2(253.14,47.26) ; v2(146.3,116.6) 145.77,116.6 145.72,116.65 RA16.1 RA16.2 RA16.4 ; C533.2 242.81,139.81 242.44,140.17 ; v1(134.76,173.95) 134.49,173.68 134.49,171.85 134.35,171.7 C478.2 ; C569.2 140.73,128.68 v1(140.97,128.92) ; v1(177.21,115.41) 177.21,115.99 C593.1 ; C494.2 145.15,163.47 145.89,164.21 C496.2 145.95,165.58 145.95,166.49 145.63,166.81 v1(143.25,166.81) ; C491.2 134.61,169.57 134.75,169.43 134.75,168.25 134.84,168.16 v1(134.84,167.65) ; v1(130.45,64.92) 130.69,64.69 130.69,64.44 C300.2 ; v1(143.25,160.41) 143.25,160.42 143.89,160.42 144.27,160.03 C503.2 ; C145.2 178.79,190.33 v2(178.05,190.33) ; C579.2 134.62,124.24 134.37,123.98 134.37,122.41 v1(134.84,121.93) ; C368.2 v2(191.53,242.35) ; C363.2 v2(293.2,100.66) ; v1(126.45,64.92) 126.1,64.56 C306.2 ; v1(175.51,184.99) 174.85,184.34 C105.2 ; R704.1 136.59,156.84 136.45,156.99 v1(136.45,158.7) ; C75.2 v2(271.15,218.48) ; C361.2 v2(189.74,246.13) ; C490.2 135.65,169.56 136.27,169.56 136.48,169.35 v1(136.48,167.64) ; C456.2 143.14,176.8 142.45,176.1 v1(142.45,175.65) ; C73.2 v2(254.74,44.39) ; v2(261.77,15.28) 261.77,14.47 262.34,13.9 FB1.1 ; C508.2 134.99,156.84 134.76,157.07 v1(134.76,158.71) ; C542.2 v1(144.4,136.41) 144.67,136.68 C548.2 ; C544.2 132.7,136.77 v1(132.55,136.63) ; v1(142.45,166.81) 143.14,167.5 C488.2 ; C657.1 190.13,75.82 190.81,75.14 v1(190.81,73.82) ; C608.2 139.09,119.65 v1(139.25,119.48) ; v2(253.21,43.5) 253.74,42.98 C415.1 ; v2(101.6,180.1) 102.47,180.1 C453.2 ; 174.65,89.35 175.07,88.93 R744.1 ; C407.1 262.49,49.09 261.74,48.33 260.79,48.33 v2(260.42,48.71) ; v1(143.25,182.05) 144.1,182.05 144.41,181.74 C450.2 ; C752.2 v2(34.2,187.35) ; C541.2 142.64,138.59 142.11,138.06 v1(142.11,137.33) ; C571.2 133.22,127.89 133.08,128.03 v1(133.08,128.92) ; C563.2 143.4,130.08 v1(143.25,129.93) 143.14,130.03 C555.2 ; v1(132.55,151.87) 132.32,152.1 C514.2 ; C546.2 139.72,134.25 v1(139.25,134.72) 138.41,134.72 C547.2 ; C301.2 133.4,64.12 133.65,63.87 v1(133.65,63.32) ; C364.2 v2(293.2,103.59) ; C465.2 144.25,175.65 v1(143.25,175.65) ; R630.2 v2(260.47,58.09) ; v1(136.48,137.16) 136.92,137.16 137.05,137.29 C543.2
  BOTTOM w0.381: C540.1 v2(134.75,139.33) ; C673.2 v2(180.88,38.86) ; R625.1 v2(28.88,233.46) ; v2(29.26,124.53) 30.52,124.53 C690.2 ; C243.2 178.01,104.91 v1(178.01,104.33) ; v2(262.76,15.38) 263.12,15.03 263.12,14.75 ; v2(91.57,183.53) 90.93,184.16 R228.1 ; R724.2 152.7,106.17 v2(153.56,106.17) ; C484.1 242.64,160.99 242.28,160.62 v2(241.71,160.62) ; C230.1 154.95,122.84 155.57,123.46 156.59,123.46 v2(157.23,122.67) ; v1(179.61,111.41) 180.25,110.77 C614.1 ; C517.2 145.16,152.28 145.72,152.83 C515.2 ; C337.2 174.04,44.33 174.84,43.53 174.84,43.38 175.43,42.79 v2(176.14,42.79) ; v2(237.24,76.44) 237.24,76.6 237.67,77.03 C375.2 ; C791.2 205.15,153.99 205.44,154.27 v2(206.04,154.27) ; v2(155.47,105.45) 155.93,105.91 C760.2 ; v2(151.46,129.17) 151.48,129.16 C561.1 ; R736.1 v2(195.76,24.2) ; v2(85.6,197.25) C425.1 84.22,196.57 84.09,196.45 C93.2 v2(85.09,195.59) ; v2(294.49,53.79) 294.38,53.67 C733.1 ; v2(125.45,15.86) 125.09,15.86 124.66,15.43 C709.2 ; C39.2 v2(50.16,229.8) ; C633.2 v2(65.99,53.2) ; C68.1 v2(166.33,218.41) ; R494.2 89.69,116.87 89.04,117.52 89.04,118.23 v2(89.69,118.88) ; v2(141.02,153.91) 140.82,153.71 140.82,153.63 140.49,153.3 C510.1 ; v1(177.51,184.63) 178.1,184.63 178.3,184.43 C144.2 ; v1(187.02,125.81) 187.63,126.42 C551.2 ; C718.2 248.67,149.04 v2(250.24,147.46) ; C721.2 249.6,141.86 250.07,142.33 v2(250.64,142.33) ; v2(170.76,140.71) 170.76,140.42 C537.1 ; C588.2 183.67,106.09 v1(183.46,106.29) ; C410.1 74.04,205.3 73.84,205.5 v2(73.53,205.5) ; C539.2 166.33,132.1 166.32,132.11 ; R699.1 v2(87.13,164.97) ; C524.2 144.24,145.17 v1(143.25,145.17) ; C218.2 C217.2 183.72,123.03 184.15,123.46 184.9,123.46 v1(185.75,122.61) 185.76,122.61 186.08,122.61 186.08,122.64 C556.2 ; v2(101.3,36.18) 101.3,34.51 101.64,34.17 C694.2 ; R771.1 104.84,40.23 104.09,39.49 v2(102.95,39.49) 102.95,40.06 103.07,40.19 C698.2 ; C652.2 293.16,54.69 v2(293.82,55.34) ; C446.1 C439.2 v2(241.03,185.67) ; C228.1 172.2,116 v1(171.61,115.41) ; v2(272.16,152.67) 272.58,152.25 C711.1 272.58,150.83 273.16,150.25 C518.2 v2(272.03,149.75) ; C312.2 175.76,53.35 v2(174.68,53.35) ; R442.1 201.41,112.79 201.99,112.21 201.99,111.68 v2(202.4,111.27) ; v2(277.47,49.31) 276.88,49.31 276.61,49.04 C674.2 ; R752.2 v2(179.64,47.27) ; v2(169.43,90.21) 169.42,90.22 169.42,90.34 170.07,89.69 C650.1 ; v1(178.81,125.01) 178.24,124.45 C211.2 ; C642.2 141.25,88.67 141.25,89.27 v2(140.84,89.68) ; C528.2 v2(142.63,141.1) ; C118.1 118.87,202.07 v2(118.24,202.71) ; v2(216.13,51.17) 216.1,51.2 R727.1 ; C125.1 238.24,176.31 v2(237.49,177.05) ; 245.01,39.55 245.34,39.22 v2(245.34,38.75) ; v2(208.64,125.62) 208.64,124.53 208.28,124.17 C585.2 ; v2(235.46,89.12) 235.43,89.14 R867.2 ; C649.1 174.65,89.35 175.51,90.21 v2(175.51,90.82) ; v2(206.68,125.47) 206.68,124.5 207.01,124.17 C585.2 ; v2(210.69,40.65) 210.69,40.08 210.71,40.07 210.71,38 210.44,37.74 C51.2 ; C724.2 v2(269.97,140.59) ; v2(243.97,163.72) 243.97,164.98 C498.2 ; C406.1 239.02,51.01 v1(239.02,51.65) ; C438.2 v2(127.89,185.31) ; v2(237.24,74.84) 237.42,74.66 237.94,74.66 238.62,73.98 C380.2 ; C389.1 C67.1 241.51,46.94 v1(242.22,47.65) ; v2(176.23,65.88) 176.83,65.88 177.39,65.32 177.39,64.48 177.08,64.16 R753.2 R754.2 173.7,64.16 ; C159.2 v2(203.56,177.28) ; C197.2 168.27,106.73 v1(168.41,106.87) ; v2(85.79,202.82) 85.73,202.76 R655.1 ; C665.1 v2(101.36,94.99) ; C381.2 232.68,74.86 232.94,75.12 v2(233.53,75.12) ; v1(172.41,124.21) 172.39,124.23 C525.1 ; v1(236.62,48.45) 235.79,48.45 C409.1 ; v1(239.82,53.25) 240.39,52.68 C55.1 ; C179.1 v2(168.27,140.95) ; R657.1 v2(230.01,39.29) ; C382.2 237.85,72.46 237.24,73.06 v2(237.24,73.24) ; C627.2 181.04,106.25 181.23,106.06 181.23,105.62 v1(181.21,105.6) ; v1(162.74,121.01) 162.8,120.95 162.8,120.79 163.11,120.49 163.87,120.49 C566.1 ; R734.2 152.81,91.71 v2(152.58,91.48) ; v2(204.83,13.35) 204.88,13.3 FB44.1 206.13,14.66 v2(206.07,14.72) ; C602.2 132.32,119.99 132,120.31 132,120.84 v1(132.55,121.39) ; R748.1 v2(152.16,248.92) ; C616.2 169.53,106.4 v1(170.01,106.87) ; C746.2 230.72,235.93 231.35,235.31 C744.2 ; C598.1 153.66,124.36 153.03,124.98 151.89,124.98 v2(151.26,124.35) ; C242.1 167.61,110.01 v1(167.61,110.61) ; v2(165.1,132.86) 165.1,133.53 C183.2 ; v2(263.75,15.38) 263.12,14.75 ; 263.12,14.75 FB1.1 ; v2(203.78,135.96) 203.6,135.77 203.6,135.37 203.29,135.06 C797.2 ; C190.1 v2(154.3,131.92) ; C342.2 158.29,45.73 v2(158.55,45.99) ; C626.2 145.44,97.36 145.52,97.44 v2(146.19,97.44) ; C761.1 208.39,182.02 v2(208.03,182.39) ; C435.2 85.23,186.05 v2(86.36,184.93) ; C704.1 v2(84.63,29.6) ; C574.1 163.32,122.79 v1(163.32,123.41) ; C661.2 43.19,114.3 43.01,114.11 v2(42.32,114.11) ; v1(241.42,50.05) 240.69,50.05 C61.1 ; C601.1 154.95,125.89 155.57,126.51 156.59,126.51 v2(157.23,125.87) ; v2(199.64,77.74) 198.96,78.42 197.93,78.42 197.22,79.14 C655.2 C659.1 ; v2(257.05,52.52) 256.9,52.36 255.62,52.36 R635.2 ; R672.1 85.08,178.97 v2(85.73,178.32) ; C199.1 162.47,125.35 162.74,125.62 v1(162.74,125.81) ; C646.2 140.48,86.26 140.84,86.63 v2(140.84,87.64) ; C487.1 138.54,168.15 v2(138.73,168.34) ; v1(173.21,119.41) 172.36,119.41 C591.1 ; C522.2 138.46,145.04 138.46,144.59 v1(138.84,144.2) ; R722.1 137.03,106.56 136.79,106.31 v2(136.75,106.31) ; R785.1 160.52,144.67 161.1,144.09 161.1,143.21 v2(160.4,142.51) ; v2(73.15,177.18) 73.55,176.78 C461.2 ; U90.8 173.84,33.16 v2(173.61,33.39) ; v2(235.46,177.05) 235.21,176.81 C123.1 233.31,176.81 v2(232.79,176.29) ; v2(241.3,34.94) 241.3,35.97 C90.1 C399.1 ; v2(93.73,19.57) 92.59,20.71 C706.1 ; C280.2 184.44,92.6 184.66,92.38 v2(184.66,91.96) 184.66,91.16 184.44,90.95 C279.1 ; C276.2 145.68,97.95 v2(146.19,97.44) ; C538.2 v1(167.12,135.4) ; C740.2 v2(246.56,237.33) ; v1(161.47,114.61) 161.47,114.1 C226.2 ; C57.1 C86.1 241.43,39.52 241.43,39.13 v2(242.14,38.42) ; v2(194.05,148.29) 193.61,148.73 C645.1 193.61,151.38 194.11,151.88 C789.1 ; v2(171.75,65.08) 171.57,65.27 171.22,65.27 170.94,64.99 170.87,64.99 170.87,64.48 170.55,64.16 R763.2 R768.2 ; C399.1 239.08,35.99 238.73,36.33 v2(238.73,37.48) ; C399.1 239.75,35.09 v2(239.78,35.07) ; v2(152.02,137.05) 152.93,137.05 153.29,136.7 C189.2 153.29,136.08 152.93,135.73 152.02,135.73 v2(151.99,135.7) ; C492.2 185.05,182.52 v2(184.94,182.41) ; 183.67,11.8 183.59,11.88 C348.2 184.86,12.89 185.22,12.54 v2(185.22,9.54) ; 183.67,11.8 v2(183.67,9.57) ; 183.67,11.8 184.48,10.99 v2(184.48,9.59) ; v2(237.49,35.32) 237.45,35.36 C388.2 ; C575.2 175.67,128.85 175.5,129.02 ; v1(153.45,65.31) 154.19,64.57 C299.2 ; C573.2 170.98,119.58 v1(170.81,119.41) ; C521.1 v2(127.77,145.87) ; C378.2 v2(246.5,76.94) ; C82.2 v2(299.08,239.92) ; C237.2 172.1,105.11 v1(171.61,105.6) ; C641.2 145.91,97.15 v2(146.19,97.44) ; C204.2 178.46,146.3 178.31,146.45 v2(178.31,147.13) ; C92.2 v2(64.9,197.12) ; C647.2 143.88,87.25 143.48,87.64 v2(142.88,87.64) ; C436.1 v2(74.68,186.65) ; C754.2 30.01,151.46 v2(30.43,151.88) ; C390.1 246.48,57.21 247.06,57.79 247.06,57.86 v1(248.22,59.02) 248.48,58.76 248.48,58.24 249.44,57.28 C47.1 ; R689.1 R683.1 67.46,175.4 67.27,175.22 v2(66.7,175.22) ; C586.2 187.92,112.65 v1(188.29,113.01) 188.32,112.98 R440.1 ; 175.5,129.02 175.5,128.18 ; 175.5,129.02 C176.2 ; C618.2 172.08,103.87 v1(171.61,104.33) ; v2(288.42,106.75) 288.12,106.45 R599.2 ; C424.1 234.16,48.44 234.99,49.27 235.1,49.27 235.12,49.25 v1(235.82,49.25) ; C400.2 77.58,210.37 77.34,210.6 v2(77.34,211.72) 77.74,211.33 C397.1 ; v2(172.9,49.93) 173.32,49.51 173.32,49.13 173.9,48.55 C329.2 ; C684.2 97.52,36.59 99.24,36.59 v2(99.64,36.18) ; C557.1 v2(154.3,132.73) ; v2(142.88,91.58) 143.52,92.23 C637.2 ; C651.2 v2(284.68,58.38) ; C485.2 249.46,160.62 v2(250.04,161.2) ; v1(140.85,113.89) 141.64,113.1 C604.2 ; v2(257.51,60.77) 259.54,60.77 259.96,61.19 R626.2 ; v2(147.99,98.19) 148.37,97.8 C632.2 ; v2(177.42,145.94) 177.52,145.84 C201.2 ; v2(153.59,133.92) 153.62,133.9 C552.2 ; C596.1 C599.1 ; C599.1 v2(193.83,109.74) ; C599.1 C609.1 v2(193.8,108.22) ; C437.2 v2(130.3,185.69) ; v2(35.51,60.39) 34.76,61.14 C734.2 ; v2(171.86,136.32) 171.87,136.32 171.87,136.35 171.83,136.35 171.83,136.21 171.7,136.08 C181.2 ; C562.2 186.03,119.41 v1(185.75,119.41) 185.01,120.16 184.28,120.16 184,119.88 C219.2 183.4,119.06 C221.2 ; v1(185.75,125.81) 185.23,126.33 C210.2 183.83,126.3 C577.2 ; v1(185.75,125.81) 186.1,125.47 C590.2 ; v1(185.75,125.81) 186.28,126.34 186.39,126.34 C549.2 ; C707.2 v2(84.87,22.09) ; C558.2 187.55,119.94 v1(187.02,119.41) ; C442.2 142.53,182.76 v1(143.25,182.05) ; C712.2 v2(280.78,151.26) ; v2(157.89,21.43) 157.85,21.39 C349.1 ; C685.2 169.74,49.93 v2(170.99,49.93) ; C519.2 255.64,149.88 255.94,150.19 C713.1 v2(254.76,151.02) ; R764.2 R765.2 C683.2 97.65,39.89 98.43,39.89 98.83,39.49 v2(99.64,39.49) 99.64,41.38 C689.2 ; v2(91.21,118.88) 90.56,118.23 90.56,117.42 R2.2 ; C244.1 168.42,121.81 v1(168.41,121.81) ; C396.1 v2(68.58,212.74) ; C559.2 138.32,128.6 137.92,128.21 136.46,128.21 v1(136.45,128.22) ; C240.2 v2(143.93,100.85) ; v2(232.79,170.83) 233.8,170.83 C140.1 ; v2(188.04,10.45) 188.07,10.42 FB46.1 187.3,9.67 v2(187.25,9.72) ; v2(41.66,175.02) 42.66,176.02 R690.1 R684.1 42.66,178.74 v2(42.93,179.01) ; C535.1 177.86,122.76 v1(178.01,122.61) ; v2(230.78,21) 230.91,21.12 232.37,21.12 FB43.1 233.79,21.17 v2(233.98,20.97) ; v1(163.05,65.31) 163.77,64.59 C298.2 ; v2(134.82,170.45) 134.82,171.04 135.38,171.6 C477.2 ; C585.2 v2(207.7,125.54) ; v2(118.9,207.23) 118.9,207.66 118.64,207.91 C103.1 117.87,207.02 117.82,206.96 C100.2 ; C776.2 223.85,246.6 v2(222.94,247.51) ; v2(174.73,65.93) 174.19,65.93 173.9,65.64 173.9,65.08 173.99,64.99 173.99,64.45 173.7,64.16 ; 242.22,50.92 v1(242.22,51.65) ; C175.2 C184.2 C527.2 180.22,128.22 179.98,127.98 ; R4.2 v2(95.9,116.77) ; v2(144.91,87.64) 146.32,87.64 C643.2 ; v2(127.62,176.16) 127.64,176.16 C458.2 ; R730.2 v2(204.23,96.42) ; C634.2 192.01,27.51 191.74,27.78 v2(191.74,27.88) ; C430.2 v2(144.02,185.69) ; C376.1 v2(282.55,102.61) ; v2(244.91,71.03) 244.91,71.34 244.66,71.58 C383.2 ; v2(123.27,18.02) 123.28,18.01 C708.2 ; v2(258.83,148.35) 259.97,148.35 261.75,150.13 262.41,150.13 262.89,150.61 C715.2 ; C666.2 v2(100.06,91.48) ; C37.2 v2(45.97,229.8) ; C749.2 v2(292.4,233.67) ; 173.7,64.16 R757.2 ; v2(135.4,92.99) 135.11,92.71 R738.2 ; C455.1 v2(137.86,184.6) ; C205.2 189.64,145.08 189.18,145.53 v2(189.18,146.12) ; C205.2 190.78,144.55 C207.2 ; C205.2 191.31,146.19 190.93,146.57 190.04,146.57 v2(189.97,146.65) ; C454.2 v2(127.58,179.21) ; R720.2 198.12,117.1 v2(198.88,117.86) ; C790.1 v2(209.63,153.91) ; C198.1 162.05,117.24 v1(162.05,117.81) ; v2(240.92,150.26) 241.17,150 C717.1 242.02,150 242.76,149.27 242.76,149.08 242.81,149.02 C520.2 ; v2(78.77,177.74) 77.39,177.74 77.07,177.42 C460.1 R686.1 ; C51.2 209.37,37.74 209.1,38 209.1,40.61 v2(209.12,40.63) ; C51.2 v2(209.91,40.63) ; v2(174.01,86.63) 174.01,87.65 C653.1 ; v2(172.9,51.63) 173.74,52.47 173.74,54.41 C310.2 ; C621.1 173.71,123.71 v1(174.01,123.41) 174.36,123.06 C248.1 ; 139.25,130.73 138.45,130.73 C554.1 ; C434.2 v2(131.83,185.69) ; C433.2 v2(134.87,185.69) ; v2(127.88,182.25) 127.84,182.25 127.84,182.21 127.89,182.21 127.89,182.26 C447.2 ; C693.2 v2(101.3,39.49) ; R696.1 v2(57.77,168.49) ; v2(152.63,93.31) 153.71,93.31 R732.2 ; C59.1 238.23,38.67 v2(238.05,38.5) ; C675.1 v2(36.03,129.99) ; C775.2 131.38,30.21 v2(131.27,30.09) ; v2(116.84,202.71) 116.44,202.3 116.44,200.84 C726.2 ; C307.2 v2(283.32,61.33) ; C379.2 240.15,75.64 v2(241.24,75.64) ; C639.2 v2(139.32,96.77) ; C35.2 v2(41.53,229.8) ; R108.1 R107.1 245.2,109.85 245.07,109.73 R95.1 v2(242.46,109.73) ; R108.1 v2(248.03,108.85) ; R108.1 R115.1 ; R873.2 201.99,151.65 201.68,151.33 v2(201.13,151.33) ; C613.2 174.46,105.26 v1(174.81,105.6) ; C671.2 v2(11.94,41.83) ; C482.2 v2(127.76,170.07) ; v2(167.13,101.39) 167.13,101.49 167.4,101.76 C249.2 C625.1 ; C617.1 170.86,124.17 v1(170.81,124.21) ; v2(135,87.3) 135,88.29 C282.2 ; 242.44,140.17 242.44,141.15 C720.1 238.86,141.24 v2(238.73,141.37) ; v2(233.48,39) 233.19,39.29 R658.1 ; v2(102.95,37.84) 103.58,37.2 C700.2 ; v2(239.67,162.3) 239.92,162.05 R702.1 ; C635.2 150.56,94.93 v2(151.95,94.93) ; v2(197.79,109.11) 197.79,109.36 197.41,109.74 C597.1 196.3,109.45 196.72,109.03 196.72,108.36 C600.2 ; C480.2 v2(139.45,185.69) ; C611.1 170.86,122.57 v1(170.81,122.61) 170.86,122.66 C620.1 ; C481.2 v2(127.6,177.69) ; C560.2 187.63,122.79 187.19,122.79 v1(187.02,122.61) ; C440.1 v2(128.4,181.75) ; C309.2 160.97,64.83 v1(161.45,65.31) ; R347.1 v2(188.36,145.83) ; C429.2 v2(127.76,168.54) ; C500.1 v2(127.47,164.9) ; C676.1 115.36,53.14 v2(116,53.79) ; C432.2 v2(137.92,185.69) ; C420.2 243.47,37.29 243.92,36.84 v2(243.97,36.84) ; C648.1 170.39,86.63 v2(169.61,86.63) ; R697.2 226.15,82.45 v2(225.63,82.97) ; C423.1 v2(232.98,58.5) ; C377.1 v2(226.68,242.85) ; C692.1 v2(285.26,38.35) ; v2(283.87,43.88) 283.79,43.96 C679.2 ; C178.1 v2(166.75,140.95) ; C431.2 v2(140.97,185.69) ; C340.2 164.85,50.15 164.59,49.9 164.59,49.81 164.54,49.76 164.54,49.34 v2(164.39,49.19) ; C65.1 v2(176.24,222.25) ; v2(109.22,90.44) 108.22,90.44 C670.2 ; C8.2 v2(258.09,19.83) ; C43.2 v2(249.85,63.12) ; C38.2 v2(48.13,229.8) ; C44.1 234.27,50.79 v1(235.02,50.05) ; C45.1 C71.1 234.22,53.99 v1(234.22,53.25) 234.22,52.44 C411.1 ; C36.2 v2(43.81,229.8) ; C403.2 v2(65.79,209.31) ; v2(167.21,86.63) 167.21,87.74 C654.1 ; R756.1 v2(273.3,49.04) ; C638.1 79.57,49.91 v2(80.14,50.48) ; v2(253.42,139.66) 254.88,139.66 255.99,140.78 C723.1 ; C699.2 v2(104.6,49.77) ; C610.1 129.62,115.46 129.86,115.22 v1(129.86,115.2) ; C672.1 v2(183.17,44.83) ; C697.2 v2(103.07,49.9) ; v2(151.26,127.4) 151.89,128.03 152.91,128.03 153.54,127.4 C565.1 ; v2(166.34,33.01) 166.5,33.16 U94.8 ; R598.2 v2(214.63,235.98) ; v1(174.81,119.41) 174.5,119.1 C191.2 ; C471.1 254.25,175.57 254.72,176.04 C468.2 258.22,176.04 v2(260.02,177.84) ; C373.1 v2(284.07,102.63) ; C470.2 v2(127.76,173.12) ; U137.2 v2(209.42,150.26)
  BOTTOM w0.508: 298.92,97.96 JP1.37 ; JP1.37 299.97,99.02 ; JP1.37 301.03,97.96 ; JP1.37 299.97,96.91 ; JP1.74 302.51,53.3 ; JP1.74 301.46,52.24 ; JP1.74 303.57,52.24 ; JP1.74 302.51,51.19 ; J6.2 15.21,236.55 ; J6.2 16.37,235.4 ; J6.2 14.06,235.4 ; J6.2 15.21,234.24 ; JP1.55 301.03,75.1 ; JP1.55 298.92,75.1 ; JP1.55 299.97,76.16 ; JP1.55 299.97,74.05 ; 302.49,177.5 J12.48 302.49,179.59 ; 106.71,209.3 J7.8 ; J7.8 105.65,210.35 ; J7.8 106.71,211.41 ; J7.8 107.76,210.35 ; JP1.25 299.97,114.26 ; JP1.25 298.92,113.2 ; JP1.25 299.97,112.15 ; JP1.25 301.03,113.2 ; 267.72,206.05 TP61.1 ; TP61.1 266.71,207.05 ; TP61.1 268.72,207.05 ; TP61.1 267.72,208.05 ; 299.97,51.19 JP1.73 ; JP1.73 299.97,53.3 ; JP1.73 298.92,52.24 ; JP1.73 301.03,52.24 ; JP1.19 301.03,120.82 ; JP1.19 298.92,120.82 ; JP1.19 299.97,121.88 ; JP1.19 299.97,119.77 ; 44.55,99.01 J49.1 ; J49.1 44.55,101.12 ; J49.1 45.61,100.07 ; J49.1 43.5,100.07 ; 70.82,225.95 MOD1.K ; MOD1.K 72.23,224.54 ; MOD1.K 72.23,227.36 ; MOD1.K 73.64,225.95 ; J18.3 268.86,124.78 ; J18.3 267.79,123.71 ; J18.3 268.86,122.65 ; J18.3 269.93,123.71 ; 301.46,113.2 JP1.26 ; JP1.26 303.57,113.2 ; JP1.26 302.51,112.15 ; JP1.26 302.51,114.26 ; 93.09,190.97 J9.3 93.09,193.11 ; J12.6 303.53,231.89 ; J12.6 301.45,231.89 ; J12.6 302.49,230.84 ; J12.6 302.49,232.93 ; TP129.1 267.3,84.11 ; TP129.1 266.29,83.11 ; TP129.1 266.29,85.12 ; TP129.1 265.29,84.11 ; J12.7 300.99,229.35 ; J12.7 299.95,230.39 ; J12.7 299.95,228.3 ; J12.7 298.91,229.35 ; 301.46,75.1 JP1.56 ; JP1.56 303.57,75.1 ; JP1.56 302.51,76.16 ; JP1.56 302.51,74.05 ; 11.68,107.39 P1.5 ; P1.5 11.68,109.5 ; P1.5 12.74,108.45 ; P1.5 10.63,108.45 ; 60.78,191.02 J10.2 ; J10.2 62.92,191.02 ; J10.2 61.85,192.09 ; J10.2 61.85,189.96 ; JP1.80 303.57,44.62 ; JP1.80 302.51,45.68 ; JP1.80 301.46,44.62 ; JP1.80 302.51,43.57 ; JP1.49 301.03,82.72 ; JP1.49 299.97,83.78 ; JP1.49 299.97,81.67 ; JP1.49 298.92,82.72 ; JP1.95 299.97,25.36 ; JP1.95 298.92,24.3 ; JP1.95 301.03,24.3 ; 104.65,166.63 TP90.1 ; TP90.1 105.65,167.63 ; TP90.1 103.64,167.63 ; TP90.1 104.65,168.63 ; JP1.85 301.03,37 ; JP1.85 299.97,38.06 ; JP1.85 299.97,35.95 ; JP1.85 298.92,37 ; JP1.31 301.03,105.58 ; JP1.31 299.97,104.53 ; JP1.31 298.92,105.58 ; JP1.31 299.97,106.64 ; 194.18,48.9 TP202.1 ; TP202.1 195.19,49.9 ; TP202.1 193.18,49.9 ; TP202.1 194.18,50.9 ; 302.51,58.81 JP1.68 ; JP1.68 303.57,59.86 ; JP1.68 301.46,59.86 ; JP1.68 302.51,60.92 ; v2(253.57,171.34) 252.68,171.34 C107.2 ; 299.97,89.29 JP1.43 ; JP1.43 298.92,90.34 ; JP1.43 301.03,90.34 ; JP1.43 299.97,91.4 ; JP1.62 302.51,68.54 ; JP1.62 303.57,67.48 ; JP1.62 301.46,67.48 ; JP1.62 302.51,66.43 ; J17.1 271.02,179.52 ; J17.1 271.02,177.38 ; J17.1 272.08,178.45 ; J17.1 269.95,178.45 ; JP1.38 302.51,99.02 ; JP1.38 303.57,97.96 ; JP1.38 302.51,96.91 ; JP1.38 301.46,97.96 ; JP1.86 302.51,38.06 ; JP1.86 303.57,37 ; JP1.86 302.51,35.95 ; JP1.86 301.46,37 ; 301.46,120.82 JP1.20 ; JP1.20 303.57,120.82 ; JP1.20 302.51,121.88 ; JP1.20 302.51,119.77 ; 302.49,213.06 J12.20 ; J12.20 303.53,214.11 ; J12.20 302.49,215.15 ; J12.20 301.45,214.11 ; 301.45,229.35 J12.8 ; J12.8 302.49,228.3 ; J12.8 302.49,230.39 ; J12.8 303.53,229.35 ; J11.3 99.36,189.75 ; J11.3 98.3,188.69 ; J11.3 98.3,190.82 ; 105.65,215.43 J7.4 ; J7.4 107.76,215.43 ; J7.4 106.71,216.49 ; J7.4 106.71,214.38 ; 301.46,24.3 JP1.96 ; JP1.96 302.51,23.25 ; JP1.96 303.57,24.3 ; JP1.96 302.51,25.36 ; 302.51,18.17 JP1.100 ; JP1.100 302.51,20.28 ; JP1.100 303.57,19.22 ; JP1.100 301.46,19.22 ; 301.46,136.06 JP1.8 ; JP1.8 303.57,136.06 ; JP1.8 302.51,135.01 ; 301.45,206.49 J12.26 ; J12.26 302.49,205.44 ; J12.26 302.49,207.53 ; 301.45,183.63 J12.44 ; J12.44 302.49,184.67 ; J12.44 302.49,182.58 ; JP1.13 299.97,129.5 ; JP1.13 301.03,128.44 ; JP1.13 299.97,127.39 ; JP1.13 298.92,128.44 ; 298.92,29.38 JP1.91 ; JP1.91 301.03,29.38 ; JP1.91 299.97,28.33 ; JP1.91 299.97,30.44 ; TP203.1 111.75,204.36 ; TP203.1 110.74,203.35 ; TP203.1 110.74,205.36 ; J7.10 107.76,207.81 ; J7.10 106.71,206.76 ; J7.10 105.65,207.81 ; J7.10 106.71,208.87 ; JP1.50 302.51,83.78 ; JP1.50 302.51,81.67 ; JP1.50 301.46,82.72 ; JP1.50 303.57,82.72 ; 166.32,132.11 v1(166.01,132.42) ; TP92.1 268.73,185.17 ; TP92.1 267.73,184.16 ; TP92.1 269.74,184.16 ; TP92.1 268.73,183.16 ; v2(170.99,53.35) 170.91,53.27 C686.2 ; 298.92,59.86 JP1.67 ; JP1.67 301.03,59.86 ; JP1.67 299.97,58.81 ; JP1.67 299.97,60.92 ; J12.31 300.99,198.87 ; J12.31 298.91,198.87 ; J12.31 299.95,199.91 ; 240.78,82.59 J4.6 ; J4.6 241.83,83.64 ; J4.6 241.83,81.54 ; 241.3,216.22 TP62.1 ; TP62.1 242.3,217.22 ; TP62.1 243.3,216.22 ; TP62.1 242.3,215.22 ; J12.5 300.99,231.89 ; J12.5 299.95,232.93 ; J12.5 298.91,231.89 ; J12.5 299.95,230.84 ; 163.03,26.81 J31.1 ; J31.1 164.01,27.79 ; J31.1 164.99,26.81 ; J31.1 164.01,25.83 ; J12.32 302.49,199.91 ; J12.32 302.49,197.82 ; J12.32 301.45,198.87 ; 260.5,13.86 J1.5 259.77,15.14 ; TP51.1 5.54,22.46 ; TP51.1 6.54,21.45 ; TP51.1 4.53,21.45 ; TP51.1 5.54,20.45 ; TP104.1 88.44,102.34 ; TP104.1 87.44,101.34 ; TP104.1 88.44,100.33 ; TP104.1 89.45,101.34 ; 298.91,176.01 J12.49 ; J12.49 299.95,174.96 ; J12.49 300.99,176.01 ; 299.97,66.43 JP1.61 ; JP1.61 298.92,67.48 ; JP1.61 301.03,67.48 ; 302.51,89.29 JP1.44 ; JP1.44 301.46,90.34 ; JP1.44 302.51,91.4 ; JP1.44 303.57,90.34 ; JP1.84 302.51,40.6 ; JP1.84 302.51,38.49 ; JP1.84 301.46,39.54 ; JP1.84 303.57,39.54 ; 299.97,43.57 JP1.79 ; JP1.79 299.97,45.68 ; JP1.79 298.92,44.62 ; JP1.79 301.03,44.62 ; 302.51,127.39 JP1.14 ; JP1.14 303.57,128.44 ; JP1.14 302.51,129.5 ; JP1.14 301.46,128.44 ; R758.2 91.87,39.23 v2(90.93,40.17) ; 298.92,136.06 JP1.7 ; JP1.7 301.03,136.06 ; JP1.7 299.97,135.01 ; C701.2 95.95,30.81 v2(96.27,30.49) ; 105.65,205.27 J7.12 ; J7.12 107.76,205.27 ; J7.12 106.71,204.22 ; J7.12 106.71,206.33 ; TP53.1 12.59,225.59 ; TP53.1 11.58,226.6 ; TP53.1 11.58,224.59 ; TP53.1 10.58,225.59 ; JP1.99 299.97,20.28 ; JP1.99 299.97,18.17 ; JP1.99 298.92,19.22 ; JP1.99 301.03,19.22 ; 110.87,200.94 TP204.1 ; TP204.1 110.87,202.95 ; TP204.1 111.87,201.94 ; 57.93,224.78 MOD1.11 57.93,223.21 ; 300.99,216.65 J12.17 299.16,215.86 ; JP1.32 303.57,105.58 ; JP1.32 302.51,104.53 ; JP1.32 301.46,105.58 ; JP1.32 302.51,106.64 ; TP201.1 158.6,231.12 ; TP201.1 159.6,230.11 ; TP201.1 158.6,229.11 ; TP201.1 157.59,230.11 ; 300.99,183.63 J12.43 299.95,182.58 ; 302.49,189.75 J12.40 302.49,187.66 ; 301.45,176.01 J12.50 ; J12.50 302.49,177.05 ; J12.50 302.49,174.96
  BOTTOM w0.762: R752.2 181.89,48.15
  BOTTOM w1.016: 181.89,48.15 v2(182.79,49.05)
  vias: v2(5.24,69.92) v2(6.43,69.92) v2(12.89,130.85) v2(14.11,131.38) v2(15.43,130.88) v2(19.05,61.99) v2(19.05,60.97) v2(19.05,59.96) v2(19.94,61.99) v2(19.94,59.96) v2(20.83,61.99) v2(20.83,60.97) v2(20.83,59.96) v2(42.37,75.88) v2(45.16,75.88) v2(60.71,173.5) v2(60.71,172.1) v2(63.88,173.5) v2(63.88,172.1) v2(78,19.47) v2(79.63,20) v2(80.95,19.4) v2(88.39,183.53) v2(88.39,182.13) v2(88.65,171.59) v2(88.65,170.19) v2(89.92,182.89) v2(90.17,170.96) v2(91.57,182.13) v2(91.59,112.18) v2(91.59,110.4) v2(91.82,171.59) v2(91.82,170.19) v2(93.37,112.18) v2(93.37,110.4) v2(101.3,37.84) v2(102.95,36.18) v2(112.4,188.48) v2(112.52,193.31) v2(113.16,188.48) v2(113.28,193.31) v2(114.43,188.1) v2(116.2,188.48) v2(117.09,188.48) v2(120.14,193.44) v2(120.9,193.44) v2(123.95,216.55) v2(123.95,215.66) v2(124.46,214.77) v2(124.59,216.55) v2(124.59,215.66) v2(131.32,229.5) v2(131.32,228.61) v2(131.32,227.73) v2(131.78,223.96) v2(132.46,229.5) v2(132.46,228.61) v2(132.46,227.73) v2(140.78,213.95) v2(140.72,212.99) v2(140.84,91.58) v2(141.22,215.53) v2(141.35,217.57) v2(141.35,216.55) v2(142.06,23.03) v2(142.01,22.01) v2(142.88,89.68) v2(143,24.35) v2(143.05,23.03) v2(143.03,21.94) v2(144.91,91.58) v2(144.91,89.68) v2(170.99,51.63) v2(171.96,148.48) v2(172.9,53.35) v2(173.48,148.48) v2(174.68,51.63) v2(174.68,49.93) v2(174.88,178.96) v2(175.51,169.05) v2(176.91,176.04) v2(177.05,141.87) v2(179.07,167.27) v2(179.32,172.86) v2(179.58,168.8) v2(179.96,170.32) v2(180.09,176.67) v2(182.5,172.23) v2(183.41,98.8) v2(186.5,164.67) v2(187.45,166.77) v2(189.99,167.91) v2(193.55,164.67) v2(193.8,166.77) v2(194.06,230.52) v2(198.37,103.9) v2(199.64,103.9) v2(200.79,106.57) v2(203.07,217.57) v2(203.2,92.34) v2(203.53,217.11) v2(203.71,83.83) v2(204.6,114.96) v2(204.88,117.77) v2(204.98,31.64) v2(207.77,31.64) v2(214.35,22.95) v2(214.48,18.79) v2(214.88,31.51) v2(217.42,31.51) v2(217.7,18.79) v2(218.95,90.57) v2(218.95,89.3) v2(220.6,89.93) v2(221.87,100.47) v2(221.87,99.2) v2(222.25,90.57) v2(222.25,89.3) v2(223.39,99.96) v2(225.17,100.47) v2(225.17,99.2) v2(231.62,170.8) v2(231.62,169.99) v2(232.79,170.02) v2(232.92,234.96) v2(232.92,177.26) v2(233.25,194.3) v2(233.27,192.85) v2(233.81,234.96) v2(233.81,233.44) v2(235.2,194.43) v2(235.2,192.9) v2(235.64,170.04) v2(236.35,177.18) v2(237.13,194.4) v2(237.16,193.23) v2(237.24,176.42) v2(237.21,170.09) v2(238.38,179.97) v2(238.4,238.04) v2(238.4,237.02) v2(238.4,236.01) v2(238.76,179.47) v2(238.84,194.3) v2(238.79,193.26) v2(239.09,167.05) v2(239.37,179.47) v2(239.42,238.04) v2(239.42,237.02) v2(239.42,236.01) v2(239.42,178.83) v2(240.03,179.47) v2(240.03,178.81) v2(240.26,168.42) v2(240.28,167.73) v2(241.6,193.66) v2(242.49,193.66) v2(243.33,184.88) v2(243.32,184.11) v2(243.54,192.6) v2(243.59,193.61) v2(243.99,104.21) v2(244.86,226.46) v2(245.01,109.21) v2(245.87,226.46) v2(246.25,190.34) v2(246.25,188.1) v2(246.25,187.34) v2(246.89,236.36) v2(246.89,234.84) v2(247.01,232.93) v2(247.01,231.15) v2(247.01,230.14) v2(247.01,229.25) v2(247.01,228.23) v2(247.01,227.34) v2(247.27,190.34) v2(247.27,188.1) v2(247.27,187.34) v2(248.03,231.15) v2(252.12,89.5) v2(252.5,85.46) v2(252.6,237.25) v2(252.6,235.73) v2(252.6,234.96) v2(260.17,181.17) v2(262.64,214.52) v2(262.64,212.99) v2(264.16,214.52) v2(266.06,192.42) v2(267.59,192.42) v2(268.99,192.42) v2(268.99,190.77) v2(268.99,189.37) v2(268.99,187.97) v2(268.99,186.7) v2(270.51,192.42) v2(270.51,190.77) v2(270.51,189.37) v2(270.51,187.97) v2(270.51,186.7) v2(280.64,95.62) v2(281.66,96.64) v2(281.66,95.62) v2(282.84,49.11) v2(284.12,199.96) v2(284.18,198.8) v2(284.12,197.78) v2(285.22,199.96) v2(285.24,197.78) v2(286.26,197.8) v2(286.31,199.96) v2(286.31,198.87) v2(287.15,35.7) v2(292.48,151.98) v2(293.09,53.79) v2(293.28,215.53) v2(293.28,212.58) v2(293.24,211.72) v2(294.16,215.53) v2(294.16,212.58) v2(294.89,211.47) v2(295.27,203.6) v2(295.27,202.71) v2(295.27,201.82) v2(295.27,200.93) v2(295.27,200.04) v2(295.31,215.53) v2(295.31,214.64) v2(295.31,213.76) v2(295.31,212.58) v2(296.29,208.68) v2(301.24,195.59) v2(301.24,192.42)
