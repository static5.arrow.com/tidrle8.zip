# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LDO4_1V8: length 17.7
  TOP w0.203: C121.2 254,177.18 253.75,177.43 250.42,177.43 248.7,175.72 U32.C8
  TOP w0.381: C121.2 C116.1
  L03_SIG1 w0.381: TP100.1 264.29,180.35 258.7,180.35 v2(258.06,179.72)
LDO5_3V3: length 19.2
  TOP w0.203: 242.82,171.17 U32.K1
  TOP w0.381: 242.82,171.17 242.36,171.17 v2(242.19,171.34)
  L08_SIG2 w0.381: TP110.1 230.76,168.54 237.36,168.54 240.16,171.34 v2(242.19,171.34)
  BOTTOM w0.381: C476.2 242.17,171.92 242.19,171.91 v2(242.19,171.34)
  BOTTOM w0.508: C469.1 C476.2
LDO6_3V3: length 56.5
  TOP w0.152: U32.M2 243.56,169.56 243.56,168.77 243.54,168.75
  TOP w0.279: C164.2 240.46,159.21 240.46,160.49 241.35,161.38 241.35,165.32 241.71,165.67 241.71,166.92 243.54,168.75
  TOP w0.381: C163.1 C164.2 v2(241.17,159.16)
  L08_SIG2 w0.508: 242.85,173.34 242.85,170.02
  L08_SIG2 w0.762: 242.85,170.02 241.1,168.26 241.1,162.14 240.26,161.31 240.26,160.24 241.17,159.32 v2(241.17,159.16) ; 242.85,173.34 240.82,175.38 240.82,184.39 239.7,185.51 TP120.1
LDO7_3V3: length 23.3
  TOP w0.152: 244.19,168.95 244.19,169.54 U32.M3
  TOP w0.203: v2(241.94,164.23) 242.52,164.81 242.52,166.91 244.19,168.58 244.19,168.95
  BOTTOM w0.381: C505.1 243.47,156.72 ; C505.1 243.47,159.22 ; C505.1 244.22,157.62 TP121.1 ; 243.47,156.72 243.88,156.31 ; 243.47,156.72 243.88,156.31 ; 243.47,159.22 C504.2 ; 243.47,159.22 243.47,159.65 243.17,159.96 241.4,159.96 241.02,160.34 241.02,160.88 241.55,161.41 241.55,163.27 241.94,163.65 v2(241.94,164.23) ; 245.2,156.31 243.88,156.31 ; 245.2,156.31 TP121.1 ; 245.2,156.31 243.88,156.31 ; 245.2,156.31 TP121.1
LDO8_3V3: length 20.3
  TOP w0.279: U32.M1 242.7,169.87 241.2,168.37 241.2,166.16 240.96,165.92 240.96,161.93 239.57,160.54 238.63,160.54
  TOP w0.381: v2(235.46,161.4) 235.46,161.3 235.33,161.18 C160.1 C161.2 237,160.54 238.63,160.54
  L08_SIG2 w0.508: TP119.1 228.6,160.66 ; TP119.1 227.6,159.65 ; TP119.1 229.6,159.65 ; TP119.1 228.6,158.65
  vias: v2(237.01,161.41)
LDO_PCIE_CAP: length 38.8
  TOP w0.127: U1.L8 v1(174.81,122.61) ; U1.J8 v1(176.41,123.41)
  L03_SIG1 w0.102: v1(174.81,122.61) 175.61,122.61 v1(176.41,123.41)
  L05_PWR1 w0.102: v1(176.41,123.41) 176.81,123.81 176.81,128.67
  L05_PWR1 w0.381: v2(187.6,142.48) 187.6,140.96 186.97,140.32 184.43,140.32 183.44,139.33 183.44,139.32 183.1,138.98 183.08,138.98 182.73,138.62 181,138.62 180.34,137.96 180.34,136.74 179.92,136.32 178.7,136.32 178.03,135.65 178.03,129.89 176.81,128.67
  BOTTOM w0.102: C575.1 176.03,127.87 176.03,124.7 176.12,124.6 176.76,124.6 176.81,124.55 176.81,123.81 v1(176.41,123.41)
  BOTTOM w0.381: v2(187.6,142.48) 187.6,142.91 187.25,143.27 FB22.2 187.88,143.86 187.95,143.93 C207.1
LDO_USB_CAP: length 25.2
  TOP w0.127: U1.H19 v1(177.21,114.61) U1.J18
  BOTTOM w0.102: 177.34,112.61 177.05,112.61 176.8,112.87 176.8,113.67 C631.1
  BOTTOM w0.127: 177.34,112.61 177.39,112.61 177.62,112.38 177.62,112.05 177.62,112.05 177.62,107.98 177.85,107.75 178.37,107.75 178.38,107.76 178.77,107.38 178.77,104.31 179.04,104.03 180.02,104.03
  BOTTOM w0.381: C631.1 177.21,114.08 v1(177.21,114.61) ; FB30.2 184.01,97.07 C251.1 182.44,97.07 181.71,97.07 181.7,97.06 181.48,97.27 181.48,98.95 182.5,99.96 182.5,101.49 181.74,102.25 181.74,102.31 180.02,104.03
LED_MODE: length 9
  TOP w0.127: U92.41 169,52.38 168.83,52.21 167.18,52.21 166.8,52.59 163.12,52.59 TP171.1 R570.2
MCASP0AHCLKX_EN: length 6.8
  TOP w0.127: U139.1 292.29,63.96 288.93,67.32 J45.2
MEM_A4: length 28
  TOP w0.127: U9.J3 v2(238.23,69.64)
  L08_SIG2 w0.127: v2(244.32,61.89) 243.61,61.89 243.46,61.74 242.7,61.74 242.27,61.31 242.09,61.31 241.96,61.18 241.96,60.16 241.84,60.04 241.58,60.04 241.46,60.16 241.46,61.18 241.33,61.31 240.13,61.31 239.88,61.56 239.88,61.95 240,62.07 240.44,62.07 240.56,62.2 240.56,62.46 240.49,62.52 240,62.52 239.88,62.65 239.88,62.87 239.98,62.98 241.32,62.98 241.5,62.8 241.5,62.22 241.62,62.09 241.88,62.09 242.01,62.22 242.01,62.9 242.08,62.98 242.24,62.98 242.37,63.1 242.37,63.36 242.24,63.48 239.98,63.48 239.88,63.59 239.88,63.99 239.98,64.09 241.15,64.09 241.27,64.22 241.27,64.47 241.15,64.6 240.03,64.6 239.88,64.75 239.88,65.01 238.4,66.48 238.4,67.83 238.23,68.01 v2(238.23,69.64)
  BOTTOM w0.127: v2(244.32,61.89) 244.79,61.89 244.97,61.71 RA11.8
MEM_A5: length 26.4
  TOP w0.127: v2(236.4,69.1) 236.4,69.19 U9.J2
  L08_SIG2 w0.127: v2(236.4,69.1) 236.75,68.75 236.75,67.07 237.46,66.35 237.46,66.34 238.23,65.57 238.23,59.82 238.1,59.69 237.29,59.69 237.16,59.57 237.16,59.31 237.29,59.19 238.1,59.19 238.2,59.08 238.2,58.28 238.4,58.08 239.29,58.08 239.42,58.21 239.42,59.35 239.57,59.5 239.83,59.5 239.95,59.37 239.95,58.59 240.08,58.46 240.33,58.46 240.46,58.59 240.46,59.37 240.59,59.5 240.84,59.5 240.97,59.37 240.97,58.59 241.1,58.46 241.35,58.46 241.48,58.59 241.48,59.27 241.6,59.4 242.52,59.4 243.87,60.75 243.87,60.75 v2(244.32,61.2)
  BOTTOM w0.127: RA11.7 v2(244.32,61.2)
MEM_A6: length 24.6
  TOP w0.127: U9.H3 238.16,70.44 v2(238.18,70.45)
  L08_SIG2 w0.127: v2(238.18,70.45) 238.02,70.6 237.11,70.6 236.8,70.3 236.32,70.3 236.14,70.12 236.14,69.79 236.3,69.64 237.29,69.64 237.66,69.27 237.66,68.44 237.19,67.98 237.19,67.3 239.23,65.26 239.23,63.91 239.34,63.79 239.34,61.61 238.81,61.08 238.81,60.04 239.04,59.81 239.29,59.81 239.42,59.93 239.42,60.62 239.55,60.75 239.8,60.75 239.93,60.62 239.93,59.93 240.06,59.81 240.31,59.81 240.44,59.93 240.44,60.62 240.56,60.75 240.82,60.75 240.94,60.62 240.94,59.93 241.07,59.81 242.37,59.81 242.98,60.42 242.98,61.04 v2(243.17,61.23)
  BOTTOM w0.127: RA11.5 v2(243.17,61.23)
MEM_A7: length 27.3
  TOP w0.127: v2(237.21,68.77) 237.26,68.82 237.26,70.02 U9.H2
  L03_SIG1 w0.127: v2(237.21,68.77) 236.85,68.77 236.5,68.42 236.5,67.81 237.55,66.76 237.73,66.76 238.24,67.27 238.42,67.27 238.6,67.09 238.6,66.91 238.09,66.4 238.09,66.22 238.26,66.04 238.44,66.04 238.96,66.56 239.14,66.56 239.32,66.38 239.32,66.2 238.8,65.68 238.8,65.5 239.01,65.3 239.19,65.3 240.37,66.49 240.55,66.49 240.73,66.31 240.73,66.13 239.54,64.94 239.54,64.76 239.72,64.58 239.9,64.58 241.09,65.77 241.27,65.77 241.45,65.59 241.45,65.41 240.26,64.22 240.26,64.04 240.69,63.61 240.87,63.61 241.76,64.5 241.94,64.5 242.12,64.32 242.12,64.14 241.23,63.25 241.23,63.07 242.07,62.24 v2(243.09,62.24)
  BOTTOM w0.127: RA11.6 243.81,61.52 v2(243.09,62.24)
MEM_A8: length 24
  TOP w0.102: U9.H1 236.03,70.45 v2(235.46,70.45)
  TOP w0.127: RA5.6 245.72,64.28 v2(245.59,64.4)
  L03_SIG1 w0.127: v2(235.46,70.45) 235.03,70.02 235.03,68.88 237.5,66.4 237.5,66.22 237.33,66.05 237.33,65.87 237.51,65.69 237.69,65.69 237.86,65.87 238.04,65.87 238.22,65.69 238.22,65.51 238.05,65.33 238.05,65.15 238.23,64.97 238.41,64.97 238.58,65.15 238.76,65.15 238.94,64.97 238.94,64.79 238.77,64.61 238.77,64.43 238.95,64.25 239.13,64.25 239.3,64.43 239.48,64.43 239.66,64.25 239.66,64.07 239.49,63.89 239.49,63.71 239.67,63.54 239.84,63.54 240.02,63.71 240.2,63.71 240.47,63.44 240.47,63.16 239.54,62.23 239.54,62.05 239.72,61.87 239.9,61.87 240.93,62.9 241,62.9 242.15,61.76 243.48,61.76 245.59,63.87 v2(245.59,64.4)
MEM_A9: length 20.9
  TOP w0.127: U9.G3 v2(238.25,71.24) ; RA5.5 246.37,64.19 v2(246.35,64.2)
  L08_SIG2 w0.127: v2(238.25,71.24) 238.68,70.8 238.68,68.91 238.63,68.85 238.63,68.13 238.81,67.95 238.81,66.72 238.99,66.54 239.17,66.54 239.74,67.11 239.92,67.11 240.1,66.93 240.1,66.75 239.53,66.18 239.53,66 239.98,65.55 240.65,65.55 242.68,63.51 243.26,63.51 243.64,63.13 244.3,63.13 244.42,63.26 244.42,63.62 244.55,63.74 244.81,63.74 244.93,63.62 244.93,63.26 245.06,63.13 245.31,63.13 245.44,63.26 245.44,63.82 245.57,63.95 245.82,63.95 245.95,63.82 245.95,63.26 246.08,63.13 246.56,63.13 246.74,63.31 246.74,64.12 246.66,64.2 v2(246.35,64.2)
MEM_A10: length 20.9
  TOP w0.102: U9.H9 242.45,70.45 v2(242.98,70.45)
  TOP w0.127: v2(243.84,63.64) 243.97,63.51 RA5.8
  L08_SIG2 w0.127: v2(242.98,70.45) 242.92,70.39 241.86,70.39 240.6,71.66 240.05,71.66 239.43,71.04 239.43,69.32 240.13,68.62 240.13,67.38 240.64,66.87 240.82,66.87 241.31,67.36 241.49,67.36 241.67,67.18 241.67,67 241.18,66.51 241.18,66.33 241.36,66.15 241.54,66.15 242.03,66.64 242.21,66.64 242.39,66.46 242.39,66.29 241.9,65.79 241.9,65.61 242.14,65.37 243.64,65.37 243.71,65.29 243.71,64.99 243.59,64.86 242.72,64.86 242.6,64.73 242.6,64.48 242.72,64.35 243.59,64.35 243.71,64.22 243.71,63.79 243.84,63.67 v2(243.84,63.64)
MEM_A11: length 22.9
  TOP w0.127: RA5.7 245.21,63.95 245.08,64.07 244.53,64.07 v2(244.35,64.25) ; U9.G2 v2(236.44,70.84)
  L03_SIG1 w0.102: 236.44,70.79 236.44,70.34 237.63,69.15
  L03_SIG1 w0.127: 237.63,69.15 237.63,68.4 239,67.03 240.35,67.03 240.94,66.44 240.97,66.44 241.25,66.16 242.02,66.16 242.15,66.03 242.15,64.63 242.27,64.51 242.53,64.51 242.66,64.63 242.66,66.03 242.78,66.16 246.08,66.16 246.28,65.95 246.28,65.67 246.13,65.52 245.87,65.52 245.74,65.39 245.74,65.27 245.62,65.14 245.36,65.14 245.23,65.27 245.23,65.39 245.11,65.52 243.56,65.52 243.47,65.43 243.47,64.87 243.87,64.48 244.12,64.48 v2(244.35,64.25) ; v2(236.44,70.84) 236.44,70.79
MEM_A12: length 7
  TOP w0.127: v2(249.02,62.04) 249.4,62.42 TP40.1
  BOTTOM w0.127: RA12.6 246.61,61.41 246.62,61.42 246.62,61.43 246.91,61.72 246.92,61.72 246.93,61.73 248.71,61.73 v2(249.02,62.04)
MEM_BA0: length 26.9
  TOP w0.127: U9.G7 240.26,71.24 v2(240.23,71.21)
  L03_SIG1 w0.127: v2(247.12,61.23) 246.62,61.72 246.62,61.99 246.49,62.12 245.06,62.12 244.93,62.24 244.93,62.5 245.06,62.63 245.4,62.63 245.53,62.75 245.53,63.21 245.65,63.34 245.91,63.34 246.04,63.21 246.04,62.75 246.16,62.63 246.49,62.63 246.62,62.75 246.62,63.73 246.85,63.96 246.85,67.62 246.79,67.68 246.79,68.09 246.85,68.15 246.85,68.4 246.72,68.53 245.77,68.53 245.64,68.66 245.64,68.91 245.77,69.04 246.72,69.04 246.85,69.17 246.85,69.85 246.63,70.07 244.81,70.07 243.64,68.9 243.64,68.34 243.15,67.86 241.86,67.86 241.53,68.19 241.53,69.92 v2(240.23,71.21)
  BOTTOM w0.127: RA12.7 v2(247.12,61.23)
MEM_BA1: length 28.3
  TOP w0.127: U9.G8 v2(242.04,70.84)
  L03_SIG1 w0.127: v2(242.04,70.84) 242.04,70.7 242.9,69.84 243.53,69.84 243.65,69.97 243.65,72.43 243.83,72.61 244.08,72.61 244.24,72.46 244.24,71.77 244.36,71.64 244.62,71.64 244.75,71.77 244.75,72.51 244.85,72.61 245.1,72.61 245.25,72.46 245.25,71.77 245.38,71.64 245.63,71.64 245.76,71.77 245.76,72.51 245.86,72.61 246.12,72.61 246.27,72.46 246.27,71.77 246.4,71.64 246.65,71.64 246.78,71.77 246.78,72.51 246.88,72.61 247.42,72.61 247.78,72.25 247.78,67.05 247.38,66.64 247.38,64.54 247.74,64.17 247.74,63.23 247.12,62.61 v2(247.12,62.24)
  BOTTOM w0.127: RA12.5 245.95,60.59 245.47,61.07 245.47,61.91 245.79,62.24 v2(247.12,62.24)
MEM_CASN: length 21.6
  TOP w0.127: U9.F7 v2(241.24,71.64) ; R88.1 v2(240.79,67.67)
  L03_SIG1 w0.127: v2(240.79,67.67) 241.8,66.66 245.92,66.66 246.46,67.2 246.46,67.71 246.08,68.09 245.77,68.09 244.75,69.1 244.35,69.1 243.94,68.7 243.94,67.93 243.36,67.35 241.88,67.35 241.2,68.04 241.2,69 240.98,69.22 240.1,69.22 239.79,69.53 239.79,71.4 240.03,71.64 v2(241.24,71.64)
MEM_CKE: length 18.6
  TOP w0.127: U9.F3 v2(237.24,71.64)
  BOTTOM w0.102: 235.1,72.46 236.42,72.46 v2(237.24,71.64)
  BOTTOM w0.127: R87.1 237.62,66.84 236.91,67.55 231.47,67.55 230.43,68.59 230.43,70.83 232.05,72.46 235.1,72.46
MEM_CLK: length 20.8
  TOP w0.127: v2(239.32,67.67) 239.27,67.62 R86.1 ; U9.F2 v2(236.44,71.64)
  L08_SIG2 w0.127: v2(236.44,71.64) 237.02,71.06 237.52,71.06 237.79,71.33 237.79,72.04 237.66,72.17 237.46,72.17 237.34,72.3 237.34,72.55 237.46,72.68 237.66,72.68 237.79,72.81 237.79,73.8 237.92,73.93 238.17,73.93 238.3,73.8 238.3,73.53 238.42,73.4 238.68,73.4 238.8,73.53 238.8,74.11 238.93,74.23 239.19,74.23 239.31,74.11 239.31,73.53 239.44,73.4 240.49,73.4 240.61,73.28 240.61,73.02 240.49,72.9 239.91,72.9 239.78,72.77 239.78,72.13 239.65,72 239.4,72 239.27,72.13 239.27,72.77 239.14,72.9 238.42,72.9 238.3,72.77 238.3,72.4 238.42,72.28 238.51,72.28 239.17,71.62 239.17,71.43 239.01,71.28 239.01,68.29 239.32,67.98 v2(239.32,67.67)
MEM_CS0N: length 22.3
  TOP w0.102: U9.G9 v2(242.98,71.24)
  TOP w0.127: R94.1 v2(250.29,67.59)
  L08_SIG2 w0.127: v2(242.98,71.24) 243.78,70.44 243.78,68 244.42,67.35 248.21,67.35 248.46,67.1 248.46,67.02 249.45,66.03 249.81,66.03 249.94,66.16 249.94,66.99 250.07,67.12 250.32,67.12 250.45,66.99 250.45,66.16 250.58,66.03 250.83,66.03 250.96,66.16 250.96,66.99 251.08,67.12 251.34,67.12 251.47,66.99 251.47,66.16 251.59,66.03 252.02,66.03 252.2,66.21 252.2,67.38 251.92,67.66 250.35,67.66 v2(250.29,67.59)
  BOTTOM w0.127: v2(250.29,67.59) 250.61,67.28 250.61,66.82 R613.1
MEM_D2: length 5.8
  TOP w0.127: U9.B8 242.04,75.63 244.58,75.63 245.21,75 RA2.2
MEM_D3: length 4.8
  TOP w0.127: U9.C9 244.5,74.44 245.08,73.85 246.35,73.85 246.37,73.84 RA2.4
MEM_D4: length 6.1
  TOP w0.127: U9.C8 242.04,74.04 244.27,74.04 245.47,72.85 RA4.1
MEM_D5: length 5.2
  TOP w0.127: RA4.2 245.59,72.2 244.16,73.64 U9.D9
MEM_D6: length 6.2
  TOP w0.127: RA4.3 245.61,71.69 244.06,73.24 242.04,73.24 U9.D8
MEM_D7: length 5.3
  TOP w0.127: RA4.4 245.73,71.05 243.94,72.84 U9.E9
MEM_D8: length 3.5
  TOP w0.127: U9.E1 234.94,72.84 234.8,72.7 RA3.1
MEM_D9: length 4.5
  TOP w0.127: U9.D2 236.43,73.23 234.29,73.23 234.17,73.34 RA3.2
MEM_D10: length 3.5
  TOP w0.127: RA3.3 234.54,73.85 234.76,73.64 U9.D1
MEM_D11: length 4.6
  TOP w0.127: RA3.4 234.53,74.5 234.99,74.04 236.45,74.04 U9.C2
MEM_D12: length 4.1
  TOP w0.127: RA1.1 233.91,75.87 235.34,74.44 U9.C1
MEM_D13: length 5
  TOP w0.127: RA1.3 234.04,77.03 235.43,75.63 236.45,75.63 U9.B2
MEM_D14: length 4
  TOP w0.127: U9.B1 235.06,75.24 233.78,76.52 RA1.2
MEM_D15: length 4.9
  TOP w0.127: RA1.4 235.2,77.68 U9.A2
MEM_RASN: length 22
  TOP w0.127: U9.F8 v2(242.04,71.64) ; R92.1 v2(247.24,67.87)
  L08_SIG2 w0.102: 243.36,73.04 241.81,73.04 241.53,72.76 241.53,72.15 v2(242.04,71.64)
  L08_SIG2 w0.127: v2(247.24,67.87) 247.24,69.53 247.08,69.7 247.08,69.88 247.89,70.69 247.89,70.87 247.71,71.05 247.53,71.05 246.72,70.23 246.54,70.23 246.36,70.41 246.36,70.59 247.18,71.4 247.18,71.58 247,71.76 246.82,71.76 246.01,70.95 245.83,70.95 245.65,71.13 245.65,71.31 246.46,72.12 246.46,72.3 246.28,72.48 246.1,72.48 245.29,71.67 245.11,71.67 244.93,71.85 244.93,72.03 245.74,72.84 245.74,73.02 245.56,73.2 245.38,73.2 244.57,72.39 244.39,72.39 243.74,73.04 243.36,73.04
MEM_WE_DQM0N: length 26.1
  TOP w0.127: U9.E8 v2(242.04,72.44)
  L03_SIG1 w0.102: 243.36,72.79 243.26,72.79 243.13,72.91 243.13,73.7 243.03,73.8 242.82,73.8 242.72,73.7 242.72,72.89 242.62,72.79 242.39,72.79 v2(242.04,72.44)
  L03_SIG1 w0.127: v2(239.67,68.38) 238.73,69.32 238.73,70 238.86,70.13 239.39,70.13 239.52,70.26 239.52,70.51 239.39,70.64 238.86,70.64 238.73,70.77 238.73,71.02 238.86,71.15 239.39,71.15 239.52,71.27 239.52,71.53 239.39,71.66 238.86,71.66 238.73,71.78 238.73,72.04 239.19,72.49 241.39,72.49 242.19,73.29 242.19,75 242.29,75.1 243.64,75.1 243.76,74.97 243.76,74.68 243.64,74.55 242.57,74.55 242.44,74.42 242.44,74.17 242.57,74.04 243.64,74.04 243.76,73.92 243.76,72.96 243.59,72.79 243.36,72.79
  BOTTOM w0.127: R619.1 239.14,66.86 238.65,67.35 238.65,67.85 ; 238.65,67.85 239.18,68.38 ; 238.65,67.85 238.65,68.21 238.82,68.38 239.18,68.38 ; 239.18,68.38 v2(239.67,68.38)
MEM_WE_DQM1N: length 38.3
  TOP w0.102: 235.1,69.23 235.28,69.23 235.81,68.7
  TOP w0.127: 235.1,69.23 233.4,69.23 231.75,67.58 230.91,67.58 230.78,67.71 230.78,68.95 230.65,69.08 230.4,69.08 230.27,68.95 230.27,67.71 230.15,67.58 229.89,67.58 229.77,67.71 229.77,68.95 229.64,69.08 229.38,69.08 229.26,68.95 229.26,67.71 229.13,67.58 228.88,67.58 228.75,67.71 228.75,68.95 228.62,69.08 228.37,69.08 228.24,68.95 228.24,67.71 228.11,67.58 227.74,67.58 227.15,68.16 227.15,73.54 227.39,73.78 229.08,73.78 229.31,73.55 229.31,71.54 229.51,71.34 231.34,71.34 232.03,72.02 235.1,72.02 235.12,72.04 U9.F1 ; 235.81,68.7 236.19,68.32 237.5,68.32 237.74,68.07 R620.1
MFP0: length 6.4
  TOP w0.127: U96.45 274.34,44.51 v2(273.84,45.01) 274.34,45.5 274.34,46.14 274.83,46.63 R535.2
  BOTTOM w0.127: R535.2 274.44,46.35 274.44,45.61 v2(273.84,45.01)
MFP1: length 6.8
  TOP w0.127: U96.46 v2(273.84,43.99) 273.3,44.53 R534.2
  BOTTOM w0.127: R534.2 273.3,44.53 v2(273.84,43.99)
MFP2: length 4.8
  TOP w0.127: TP164.1 272.41,45.73 272.41,44.65 273.34,43.72 U96.47
MFP3: length 2.7
  TOP w0.127: U96.48 272.84,43.72 272.08,44.48 271.77,44.48 TP165.1
MIPI_EMU02: length 79.7
  TOP w0.127: J19.13 v2(222.18,82.31)
  L03_SIG1 w0.127: v2(222.18,82.31) 222.88,83.01 222.88,84.06 222.22,84.72 219.07,84.72 217.3,86.5 217.3,87.29 216.37,88.21 216.37,88.22 216.1,88.48 216.1,88.48 214.55,90.03 212.87,90.03 212.74,89.91 212.74,89.75 212.62,89.63 212.36,89.63 212.24,89.75 212.24,89.91 212.11,90.03 211.48,90.03 210.46,89.02 209.31,89.02 209.19,89.14 209.19,89.46 209.06,89.59 208.81,89.59 208.68,89.46 208.68,89.14 208.55,89.02 208.3,89.02 208.17,89.14 208.17,89.46 208.04,89.59 207.79,89.59 207.66,89.46 207.66,89.14 207.54,89.02 207.28,89.02 207.16,89.14 207.16,89.46 207.03,89.59 206.77,89.59 206.65,89.46 206.65,89.14 206.52,89.02 206.27,89.02 206.14,89.14 206.14,89.46 206.01,89.59 205.76,89.59 205.63,89.46 205.63,89.14 205.5,89.02 205.25,89.02 205.12,89.14 205.12,89.46 205,89.59 204.74,89.59 204.62,89.46 204.62,89.14 204.49,89.02 204.23,89.02 204.11,89.14 204.11,89.46 203.98,89.59 203.73,89.59 203.6,89.46 203.6,89.14 203.47,89.02 203.22,89.02 203.09,89.14 203.09,89.46 202.96,89.59 202.71,89.59 202.58,89.46 202.58,89.14 202.46,89.02 202.2,89.02 202.08,89.14 202.08,89.46 201.95,89.59 201.69,89.59 201.57,89.46 201.57,89.14 201.44,89.02 201.19,89.02 201.06,89.14 201.06,89.46 200.93,89.59 200.68,89.59 200.55,89.46 200.55,89.14 200.42,89.02 200.17,89.02 200.04,89.14 200.04,89.46 199.92,89.59 199.66,89.59 199.54,89.46 199.54,89.14 199.41,89.02 199.15,89.02 199.03,89.14 199.03,89.46 198.9,89.59 198.65,89.59 198.52,89.46 198.52,89.14 198.39,89.02 198.14,89.02 198.01,89.14 198.01,89.46 197.88,89.59 197.63,89.59 197.5,89.46 197.5,89.14 197.38,89.02 197.12,89.02 197,89.14 197,89.46 196.87,89.59 196.61,89.59 196.49,89.46 196.49,89.14 196.36,89.02 196.11,89.02 195.98,89.14 195.98,89.46 195.85,89.59 195.6,89.59 195.47,89.46 195.47,89.14 195.34,89.02 195.09,89.02 194.96,89.14 194.96,89.46 194.84,89.59 194.58,89.59 194.46,89.46 194.46,89.14 194.33,89.02 194.07,89.02 193.95,89.14 193.95,89.46 193.82,89.59 193.57,89.59 193.44,89.46 193.44,89.14 193.34,89.04 192.79,89.04 189.27,92.56 188.93,92.56 186.37,95.11 184.86,95.11 180.75,99.23 178.1,99.23 175.74,101.59 174.6,101.59 174.3,101.29 174.3,100.73 173.99,100.42 173.61,100.42 173.3,100.73 173.3,101.34 v2(173.29,101.34)
  BOTTOM w0.127: v2(173.29,101.34) 173.3,101.34 RA18.13
MIPI_EMU03: length 84.8
  TOP w0.127: J19.17 v2(221.18,82.31)
  L03_SIG1 w0.127: v2(172.48,100.7) 172.9,100.7 173.48,100.12 174.2,100.12 174.67,100.59 175.16,100.59 175.53,100.95 175.89,100.95 178.13,98.72 180.9,98.72 184.84,94.78 186.2,94.78 189.71,91.27 189.71,90.08 190.17,89.63 191.8,89.63 192.85,88.57 202.85,88.57 202.98,88.45 202.98,88.1 203.1,87.98 203.36,87.98 203.49,88.1 203.49,88.45 203.61,88.57 203.87,88.57 203.99,88.45 203.99,88.1 204.12,87.98 204.37,87.98 204.5,88.1 204.5,88.45 204.63,88.57 204.88,88.57 205.01,88.45 205.01,88.1 205.14,87.98 205.39,87.98 205.52,88.1 205.52,88.45 205.64,88.57 205.9,88.57 206.03,88.45 206.03,88.1 206.15,87.98 206.41,87.98 206.53,88.1 206.53,88.45 206.66,88.57 206.91,88.57 207.04,88.45 207.04,88.1 207.17,87.98 207.42,87.98 207.55,88.1 207.55,88.45 207.68,88.57 207.93,88.57 208.06,88.45 208.06,88.1 208.18,87.98 208.44,87.98 208.57,88.1 208.57,88.45 208.69,88.57 209.97,88.57 210.79,87.75 212.9,87.75 213.13,87.98 213.92,87.98 214.71,87.19 215.72,87.19 216.69,86.22 216.92,86.22 219.02,84.11 220.52,84.11 221.18,83.46 221.18,82.89 220.73,82.44 220.73,82.18 220.22,81.68 220.22,81.33 220.34,81.21 220.98,81.21 221.11,81.08 221.11,80.83 220.98,80.7 220.34,80.7 220.22,80.57 220.22,80.32 220.34,80.19 220.98,80.19 221.11,80.06 221.11,79.81 220.98,79.68 220.34,79.68 220.22,79.56 220.22,79.3 220.34,79.18 220.98,79.18 221.11,79.05 221.11,78.79 220.98,78.67 220.34,78.67 220.22,78.54 220.22,78.29 220.57,77.94 221.28,77.94 221.61,78.27 221.61,79.4 221.74,79.53 222.33,79.53 222.45,79.65 222.45,79.91 222.33,80.04 221.74,80.04 221.61,80.16 221.61,80.42 221.74,80.54 222.33,80.54 222.45,80.67 222.45,80.92 222.33,81.05 221.74,81.05 221.61,81.18 221.61,81.88 v2(221.18,82.31)
  BOTTOM w0.127: RA18.11 172.3,100.48 172.49,100.68 172.49,100.7 v2(172.48,100.7)
MIPI_EMU04: length 80.1
  TOP w0.127: J19.23 v2(219.68,83.2)
  L03_SIG1 w0.127: v2(173.8,100.88) 173.8,101.6 174.04,101.84 175.89,101.84 178.26,99.48 180.84,99.48 184.92,95.39 186.49,95.39 187.93,93.94 189.04,93.94 189.31,93.68 189.31,92.88 192.1,90.08 195.56,90.08 195.92,90.44 196.2,90.44 196.43,90.21 196.71,90.21 196.94,90.44 197.21,90.44 197.44,90.21 197.72,90.21 197.95,90.44 198.23,90.44 198.46,90.21 198.74,90.21 198.97,90.44 199.25,90.44 199.48,90.21 199.75,90.21 199.98,90.44 200.26,90.44 200.49,90.21 200.77,90.21 201,90.44 201.28,90.44 201.51,90.21 201.79,90.21 202.02,90.44 202.29,90.44 202.52,90.21 202.8,90.21 203.03,90.44 203.31,90.44 203.54,90.21 203.82,90.21 204.05,90.44 204.33,90.44 204.56,90.21 204.83,90.21 205.06,90.44 205.34,90.44 205.57,90.21 205.85,90.21 206.08,90.44 206.36,90.44 206.59,90.21 209.22,90.21 209.37,90.36 214.71,90.36 217.68,87.39 217.68,86.65 219.37,84.97 222.12,84.97 222.32,84.97 223.15,84.14 223.15,78.26 222.5,77.61 219.99,77.61 219.68,77.92 v2(219.68,83.2)
  BOTTOM w0.127: RA18.14 v2(173.8,100.88)
MIPI_EMU05: length 83.4
  TOP w0.127: J19.25 v2(219.18,82.31)
  L03_SIG1 w0.127: v2(219.18,82.31) 219.18,82.99 219.18,82.99 219.18,83.48 216.92,85.74 215.29,85.74 215.16,85.87 215.16,86.58 215.04,86.71 214.78,86.71 214.66,86.58 214.66,85.87 214.53,85.74 214.27,85.74 214.15,85.87 214.15,86.58 214.02,86.71 213.77,86.71 213.64,86.58 213.64,85.87 213.51,85.74 213.26,85.74 213.13,85.87 213.13,86.58 213,86.71 212.75,86.71 212.62,86.58 212.62,85.87 212.5,85.74 212.24,85.74 212.12,85.87 212.12,86.58 211.99,86.71 211.73,86.71 211.61,86.58 211.61,85.87 211.48,85.74 211.23,85.74 211.1,85.87 211.1,86.58 210.97,86.71 210.72,86.71 210.59,86.58 210.59,85.87 210.46,85.74 210.21,85.74 210.08,85.87 210.08,87.42 209.96,87.54 209.7,87.54 209.58,87.42 209.58,85.87 209.45,85.74 209.19,85.74 209.07,85.87 209.07,87.42 208.94,87.54 208.69,87.54 208.56,87.42 208.56,85.87 208.43,85.74 208.18,85.74 208.05,85.87 208.05,87.42 207.92,87.54 207.67,87.54 207.54,87.42 207.54,85.87 207.42,85.74 207.16,85.74 207.04,85.87 207.04,87.42 206.91,87.54 206.65,87.54 206.53,87.42 206.53,85.87 206.4,85.74 206.15,85.74 206.02,85.87 206.02,87.42 205.89,87.54 205.64,87.54 205.51,87.42 205.51,85.87 205.38,85.74 205.13,85.74 205,85.87 205,87.42 204.88,87.54 204.62,87.54 204.5,87.42 204.5,85.87 204.37,85.74 204.11,85.74 201.52,88.33 192.56,88.33 191.52,89.37 189.89,89.37 189.38,89.88 189.38,91.2 186.13,94.45 184.77,94.45 180.78,98.44 175.51,98.44 175.13,98.82 175.13,99.02 175.37,99.27 v2(175.45,99.27)
  BOTTOM w0.127: RA18.16 v2(175.45,99.27)
MIPI_EMU06: length 83.9
  TOP w0.127: J19.27 v2(218.68,83.2)
  L03_SIG1 w0.127: v2(218.68,83.2) 218.68,82.76 218.69,82.75 218.69,80.92 218.56,80.79 218.24,80.79 218.11,80.66 218.11,80.41 218.24,80.28 218.56,80.28 218.69,80.15 218.69,77.83 220.18,76.34 221.67,76.34 223.43,78.11 223.43,84.2 222.71,84.92 222.42,85.21 219.58,85.21 218.52,86.27 218.52,86.93 218.64,87.06 218.64,87.49 215.42,90.72 191.87,90.72 189.84,92.75 189.84,93.72 189.36,94.2 188.13,94.2 186.64,95.7 184.96,95.7 180.91,99.75 178.37,99.75 176.02,102.1 173.21,102.1 171.23,100.11 v2(171.23,100.03)
  BOTTOM w0.127: RA18.9 171.24,100.03 v2(171.23,100.03)
MIPI_EMU07: length 78.9
  TOP w0.127: J19.29 v2(218.18,82.31)
  L03_SIG1 w0.127: v2(218.18,82.31) 218.18,83.15 218.14,83.2 218.14,83.26 217.3,84.1 214.32,84.1 214.2,84.23 214.2,85.21 214.07,85.33 213.82,85.33 213.69,85.21 213.69,84.23 213.56,84.1 213.31,84.1 213.18,84.23 213.18,85.21 213.05,85.33 212.8,85.33 212.67,85.21 212.67,84.23 212.55,84.1 212.29,84.1 212.16,84.23 212.16,85.21 212.04,85.33 211.78,85.33 211.66,85.21 211.66,84.23 211.53,84.1 211.28,84.1 211.15,84.23 211.15,85.21 211.02,85.33 210.77,85.33 210.64,85.21 210.64,84.23 210.51,84.1 210.26,84.1 210.13,84.23 210.13,85.21 210.01,85.33 209.75,85.33 209.62,85.21 209.62,84.23 209.5,84.1 209.24,84.1 209.12,84.23 209.12,85.21 208.99,85.33 208.74,85.33 208.61,85.21 208.61,84.23 208.48,84.1 208.23,84.1 208.1,84.23 208.1,85.21 207.97,85.33 207.72,85.33 207.59,85.21 207.59,84.23 207.47,84.1 207.21,84.1 207.08,84.23 207.08,85.21 206.96,85.33 206.7,85.33 206.58,85.21 206.58,84.23 206.45,84.1 206.2,84.1 206.07,84.23 206.07,85.21 205.94,85.33 205.69,85.33 205.56,85.21 205.56,84.23 205.43,84.1 205.27,84.1 201.45,87.92 192.18,87.92 190.98,89.12 190.3,89.12 189.99,88.81 188.54,88.81 188.32,89.04 188.32,89.22 189.1,90.01 189.1,91.09 186.81,93.38 186.63,93.38 186.55,93.3 186.37,93.3 186.19,93.48 186.19,93.66 186.27,93.74 186.27,93.92 186.09,94.1 185.75,94.1 185.62,93.97 185.62,93.74 185.49,93.61 185.24,93.61 185.11,93.74 185.11,93.97 184.99,94.1 184.73,94.1 184.36,94.47 184.18,94.47 184.01,94.31 183.84,94.31 183.66,94.49 183.66,94.67 183.82,94.83 183.82,95.01 180.91,97.92 175.65,97.92 174.99,98.58 174.99,98.61 174.88,98.72 v2(174.88,100.09)
  BOTTOM w0.127: v2(174.88,100.09) 174.62,100.09 174.3,99.77 RA18.15
MIPI_EMU08: length 84
  TOP w0.127: J19.31 v2(217.68,83.07)
  L03_SIG1 w0.127: v2(171.86,101.41) 171.8,101.41 171.8,101.34 172.82,102.35 176.07,102.35 176.09,102.34 176.12,102.34 178.34,100.12 180.88,100.12 185.02,95.98 186.79,95.98 187.5,95.26 189.89,95.26 191.69,93.46 191.69,92.95 193.57,91.07 214.41,91.07 214.44,91.05 214.82,91.05 214.84,91.07 216.31,91.07 218.95,88.43 219.71,88.43 220.9,87.24 220.9,87.07 223.71,84.27 223.71,77.94 221.65,75.88 220.29,75.88 217.69,78.49 217.69,82.62 217.68,82.63 v2(217.68,83.07)
  BOTTOM w0.127: RA18.10 171.8,101.36 v2(171.86,101.41)
MIPI_EMU09: length 83
  TOP w0.127: J19.33 v2(217.18,82.31)
  L03_SIG1 w0.127: v2(172.8,100.09) 172.8,99.2 172.67,99.07 172.18,99.07 172.05,99.2 172.05,99.46 171.92,99.58 171.67,99.58 171.54,99.46 171.54,99.2 171.42,99.07 171.32,99.07 171.2,98.94 171.2,98.69 171.32,98.56 171.42,98.56 171.54,98.44 171.54,97.9 171.42,97.77 170.43,97.77 170.31,97.64 170.31,97.39 170.43,97.26 171.42,97.26 171.54,97.14 171.54,97.04 171.67,96.92 171.92,96.92 172.05,97.04 172.05,97.14 172.18,97.27 172.85,97.27 172.97,97.4 172.97,97.65 172.85,97.78 172.18,97.78 172.05,97.9 172.05,98.44 172.18,98.56 172.67,98.56 173.56,97.68 173.82,97.68 173.95,97.55 173.95,97.1 174.08,96.97 174.33,96.97 174.46,97.1 174.46,98.19 174.59,98.31 174.84,98.31 174.97,98.19 174.97,96.59 175.09,96.46 175.35,96.46 175.47,96.59 175.47,97.55 175.6,97.68 180.81,97.68 182.67,95.82 182.67,95.64 182.49,95.46 182.49,95.28 182.67,95.1 182.85,95.1 183.03,95.28 183.21,95.28 183.39,95.1 183.39,94.92 183.2,94.74 183.2,94.56 184.14,93.63 184.14,93.45 183.81,93.12 183.81,92.94 183.99,92.76 184.17,92.76 184.5,93.09 184.68,93.09 185.29,92.47 185.58,92.47 185.7,92.34 185.7,91.95 185.83,91.82 186.08,91.82 186.21,91.95 186.21,92.34 186.34,92.47 187.32,92.47 188.81,90.98 188.81,90.07 188.39,89.65 185.52,89.65 185.01,89.14 185.01,88.86 185.5,88.38 189.92,88.38 190.4,88.86 190.88,88.86 192.28,87.47 199.72,87.47 200.48,86.71 202.11,86.71 204.95,83.86 216.74,83.86 217.18,83.42 v2(217.18,82.31)
  BOTTOM w0.127: RA18.12 v2(172.8,100.09)
MIPI_EMU10: length 82
  TOP w0.127: J19.35 v2(216.68,82.9)
  L03_SIG1 w0.127: v2(181.23,78.91) 183.18,78.91 183.74,79.47 199.29,79.47 200.25,78.5 211.71,78.5 212.69,77.52 215.33,77.52 216.68,78.88 v2(216.68,82.9)
  L08_SIG2 w0.127: v2(181.23,78.91) 180.92,79.21 180.92,80.46 181.2,80.74 181.2,82.41 180.86,82.76 180.18,82.76 179.81,83.13 179.81,85.38 176.45,88.74 167,88.74 164.52,91.23 164.52,96.03 167.08,98.59 167.31,98.59 168.67,99.95 v2(168.67,100.9)
  BOTTOM w0.127: RA19.14 v2(168.67,100.9)
MIPI_EMU11: length 83.6
  TOP w0.127: J19.37 v2(216.18,82.31)
  L03_SIG1 w0.127: v2(180.47,79.01) 180.95,79.49 183.43,79.49 183.64,79.71 199.45,79.71 199.69,79.47 211.12,79.47 212.79,77.8 215.18,77.8 216.18,78.81 v2(216.18,82.31)
  L08_SIG2 w0.127: v2(180.47,79.01) 178.54,80.94 178.54,84.65 175.72,87.47 166.49,87.47 165.65,88.31 162.66,91.3 162.66,91.53 162.66,98.43 163.23,99 163.66,99 163.89,99 166.78,101.88 167.3,101.88 167.67,101.51 v2(167.67,100.9)
  BOTTOM w0.127: RA19.12 v2(167.67,100.9)
MIPI_EMU12: length 80.2
  TOP w0.127: v2(215.57,78.88) 215.68,78.99 J19.39
  L03_SIG1 w0.127: v2(181.41,79.95) 183.2,79.95 183.33,80.08 183.33,80.61 183.46,80.74 183.71,80.74 183.84,80.61 183.84,80.08 183.96,79.95 184.22,79.95 184.35,80.08 184.35,80.61 184.47,80.74 184.73,80.74 184.85,80.61 184.85,80.08 184.98,79.95 185.23,79.95 185.36,80.08 185.36,80.61 185.49,80.74 185.74,80.74 185.87,80.61 185.87,80.08 186,79.95 186.25,79.95 186.38,80.08 186.38,80.61 186.5,80.74 186.76,80.74 186.89,80.61 186.89,80.08 187.01,79.95 187.27,79.95 187.39,80.08 187.39,80.61 187.52,80.74 187.77,80.74 187.9,80.61 187.9,80.08 188.03,79.95 188.95,79.95 190.55,81.55 192.47,81.55 192.47,81.55 192.85,81.55 192.85,81.55 193.4,81.55 194.08,80.86 201.4,80.86 202.31,79.95 211.05,79.95 212.83,78.17 214.86,78.17 v2(215.57,78.88)
  L08_SIG2 w0.127: v2(181.41,79.95) 181.51,80.05 181.51,82.49 181,83 180.49,83 180.06,83.43 180.06,85.49 176.56,88.99 167.11,88.99 164.77,91.33 164.77,95.93 167.18,98.34 167.41,98.34 169.06,99.99 v2(169.17,99.99)
  BOTTOM w0.127: v2(169.17,99.99) 169.14,99.99 169.14,99.94 169.17,99.91 RA19.15
MIPI_EMU13: length 81.3
  TOP w0.127: J19.41 v2(215.18,82.31)
  L03_SIG1 w0.127: v2(180.54,83.86) 181.56,84.88 182.4,84.88 183.44,83.83 183.76,83.83 183.89,83.96 183.89,84.75 184.02,84.88 184.27,84.88 184.4,84.75 184.4,83.96 184.53,83.83 184.78,83.83 184.91,83.96 184.91,84.75 185.03,84.88 185.29,84.88 185.41,84.75 185.41,83.96 185.54,83.83 185.8,83.83 185.92,83.96 185.92,84.75 186.05,84.88 186.3,84.88 186.43,84.75 186.43,83.96 186.56,83.83 188.14,83.83 189.2,84.9 200.67,84.9 203.3,82.27 203.31,82.27 203.33,82.26 205.56,82.26 206.2,81.63 212.34,81.63 214.29,83.57 214.89,83.57 215.18,83.28 215.18,83.21 215.18,83.2 v2(215.18,82.31)
  L08_SIG2 w0.127: v2(169.57,100.9) 169.7,100.78 169.7,99.79 167.99,98.08 167.28,98.08 165.02,95.82 165.02,91.43 167.21,89.25 178.23,89.25 181.64,85.84 181.64,84.95 v2(180.54,83.86)
  BOTTOM w0.127: RA19.16 169.73,100.74 v2(169.57,100.9)
MIPI_EMU14: length 84.4
  TOP w0.127: J19.43 v2(214.68,83.07)
  L03_SIG1 w0.127: v2(180.47,82.06) 181.3,82.89 181.3,83.07 180.97,83.4 180.97,83.58 181.15,83.76 181.33,83.76 181.66,83.43 181.84,83.43 182.02,83.61 182.02,83.79 181.69,84.12 181.69,84.3 181.87,84.48 182.11,84.48 183.11,83.48 188.72,83.48 188.85,83.61 188.85,83.91 188.98,84.04 189.23,84.04 189.36,83.91 189.36,83.61 189.49,83.48 189.74,83.48 189.87,83.61 189.87,83.91 189.99,84.04 190.25,84.04 190.38,83.91 190.38,83.61 190.5,83.48 193.48,83.48 193.61,83.61 193.61,84.04 193.74,84.17 193.99,84.17 194.12,84.04 194.12,83.61 194.24,83.48 194.5,83.48 194.63,83.61 194.63,84.04 194.75,84.17 195.01,84.17 195.13,84.04 195.13,83.61 195.26,83.48 195.51,83.48 195.64,83.61 195.64,84.04 195.77,84.17 196.02,84.17 196.15,84.04 196.15,83.61 196.28,83.48 196.53,83.48 196.66,83.61 196.66,84.04 196.78,84.17 197.04,84.17 197.17,84.04 197.17,83.61 197.29,83.48 197.55,83.48 197.67,83.61 197.67,84.04 197.8,84.17 198.05,84.17 198.18,84.04 198.18,83.61 198.31,83.48 198.56,83.48 198.69,83.61 198.69,84.04 198.82,84.17 199.07,84.17 199.2,84.04 199.2,83.61 199.32,83.48 199.58,83.48 199.71,83.61 199.71,84.04 199.83,84.17 200.09,84.17 200.21,84.04 200.21,83.61 200.34,83.48 201.47,83.48 203.07,81.88 205.21,81.88 205.74,81.35 212.52,81.35 213.98,82.81 213.98,82.81 214.24,83.07 v2(214.68,83.07)
  L08_SIG2 w0.127: v2(167.17,100.12) 167.17,99.9 166.57,99.3 165.77,99.3 164.01,97.54 164.01,91.02 166.8,88.23 176.21,88.23 179.31,85.13 179.31,82.53 179.78,82.06 v2(180.47,82.06)
  BOTTOM w0.127: RA19.11 v2(167.17,100.12)
MIPI_EMU15: length 83.2
  TOP w0.127: J19.45 v2(214.18,82.31)
  L03_SIG1 w0.127: v2(180.47,81.29) 181.75,82.58 182.25,82.58 182.37,82.7 182.37,82.92 182.5,83.05 182.75,83.05 182.88,82.92 182.88,82.7 183.01,82.58 183.26,82.58 183.39,82.7 183.39,82.92 183.52,83.05 183.77,83.05 183.9,82.92 183.9,82.7 184.02,82.58 184.28,82.58 184.4,82.7 184.4,82.92 184.53,83.05 184.79,83.05 184.91,82.92 184.91,82.7 185.04,82.58 185.29,82.58 185.42,82.7 185.42,82.92 185.55,83.05 185.8,83.05 185.93,82.92 185.93,82.7 186.06,82.58 186.31,82.58 186.44,82.7 186.44,82.92 186.56,83.05 186.82,83.05 186.94,82.92 186.94,82.7 187.07,82.58 187.33,82.58 187.45,82.7 187.45,82.92 187.58,83.05 187.83,83.05 187.96,82.92 187.96,82.7 188.09,82.58 188.34,82.58 188.47,82.7 188.47,82.92 188.6,83.05 188.85,83.05 188.98,82.92 188.98,82.7 189.1,82.58 189.36,82.58 189.48,82.7 189.48,82.92 189.61,83.05 189.87,83.05 189.99,82.92 189.99,82.7 190.12,82.58 190.37,82.58 190.5,82.7 190.5,82.92 190.63,83.05 190.88,83.05 191.01,82.92 191.01,82.7 191.14,82.58 191.39,82.58 191.52,82.7 191.52,82.92 191.64,83.05 191.9,83.05 192.02,82.92 192.02,82.7 192.15,82.58 192.41,82.58 192.53,82.7 192.53,82.92 192.66,83.05 192.91,83.05 193.04,82.92 193.04,82.7 193.17,82.58 193.42,82.58 193.55,82.7 193.55,82.92 193.68,83.05 193.93,83.05 194.06,82.92 194.06,82.7 194.18,82.58 194.44,82.58 194.56,82.7 194.56,82.92 194.69,83.05 194.95,83.05 195.07,82.92 195.07,82.7 195.2,82.58 195.45,82.58 195.58,82.7 195.58,82.92 195.71,83.05 195.96,83.05 196.09,82.92 196.09,82.7 196.22,82.58 196.47,82.58 196.6,82.7 196.6,82.92 196.72,83.05 196.98,83.05 197.1,82.92 197.1,82.7 197.23,82.58 197.49,82.58 197.61,82.7 197.61,82.92 197.74,83.05 197.99,83.05 198.12,82.92 198.12,82.7 198.25,82.58 198.5,82.58 198.63,82.7 198.63,82.92 198.76,83.05 199.01,83.05 199.14,82.92 199.14,82.7 199.23,82.62 201.65,82.62 202.65,81.61 204.97,81.61 205.54,81.04 212.91,81.04 v2(214.18,82.31)
  L08_SIG2 w0.127: v2(168.17,100.12) 167.97,100.12 166.9,99.05 165.89,99.05 164.26,97.42 164.26,91.12 166.9,88.48 176.35,88.48 179.55,85.28 179.55,82.87 179.91,82.51 180.67,82.51 180.92,82.26 180.92,82.23 180.95,82.21 180.95,81.78 v2(180.47,81.29)
  BOTTOM w0.127: RA19.13 v2(168.17,100.12)
MIPI_EMU16: length 75.7
  TOP w0.127: v2(214,78.75) 213.68,79.07 J19.47
  L03_SIG1 w0.127: v2(180.47,80.53) 181.99,82.06 195.02,82.06 195.07,82.11 200.38,82.11 200.53,82.26 201.32,82.26 203.02,80.56 203.28,80.56 203.4,80.69 203.4,81.14 203.53,81.27 203.78,81.27 203.91,81.14 203.91,80.69 204.04,80.56 204.29,80.56 204.42,80.69 204.42,81.14 204.55,81.27 204.8,81.27 204.93,81.14 204.93,80.69 205.05,80.56 212.75,80.56 214,79.31 v2(214,78.75)
  L08_SIG2 w0.127: v2(166.67,100.73) 166.67,99.98 166.31,99.62 165.75,99.62 163.75,97.63 163.75,90.92 166.7,87.98 176.07,87.98 179.07,84.97 179.07,81.93 v2(180.47,80.53)
  BOTTOM w0.127: RA19.10 v2(166.67,100.73)
MIPI_EMU17: length 78.2
  TOP w0.127: J19.49 v2(213.18,78.88)
  L03_SIG1 w0.127: v2(180.47,79.77) 181.95,81.26 189.9,81.26 190.45,81.8 193.6,81.8 194.28,81.12 194.56,81.12 194.69,81.24 194.69,81.63 194.82,81.75 195.07,81.75 195.2,81.63 195.2,81.24 195.33,81.12 195.58,81.12 195.71,81.24 195.71,81.63 195.83,81.75 196.09,81.75 196.22,81.63 196.22,81.24 196.34,81.12 196.6,81.12 196.72,81.24 196.72,81.63 196.85,81.75 197.1,81.75 197.23,81.63 197.23,81.24 197.36,81.12 197.61,81.12 197.74,81.24 197.74,81.63 197.87,81.75 198.12,81.75 198.25,81.63 198.25,81.24 198.37,81.12 198.63,81.12 198.75,81.24 198.75,81.63 198.88,81.75 199.14,81.75 199.26,81.63 199.26,81.24 199.39,81.12 199.64,81.12 199.77,81.24 199.77,81.63 199.9,81.75 200.15,81.75 200.28,81.63 200.28,81.24 200.41,81.12 201.5,81.12 202.36,80.25 211.81,80.25 v2(213.18,78.88)
  L08_SIG2 w0.127: v2(180.47,79.77) 178.78,81.46 178.78,84.87 175.93,87.72 166.6,87.72 162.94,91.38 162.94,98.31 163.35,98.72 164.01,98.72 165.41,100.12 v2(166.11,100.12)
  BOTTOM w0.127: RA19.9 v2(166.11,100.12)
MIPI_EMU18: length 81.4
  TOP w0.127: v2(212.14,83.23) 212.68,82.68 J19.51
  L03_SIG1 w0.127: v2(212.14,83.23) 212.12,83.2 210.24,83.2 210.11,83.07 210.11,82.31 209.98,82.18 209.73,82.18 209.6,82.31 209.6,83.07 209.48,83.2 209.22,83.2 209.09,83.07 209.09,82.31 208.97,82.18 208.71,82.18 208.59,82.31 208.59,83.07 208.46,83.2 208.21,83.2 208.08,83.07 208.08,82.31 207.95,82.18 207.7,82.18 207.57,82.31 207.57,83.07 207.44,83.2 207.19,83.2 207.06,83.07 207.06,82.31 206.94,82.18 206.68,82.18 206.55,82.31 206.55,83.07 206.43,83.2 205.26,83.2 203.5,84.96 202.92,85.54 201.83,85.54 201.71,85.66 201.71,86.2 201.58,86.32 201.33,86.32 201.2,86.2 201.2,85.66 201.07,85.54 199.64,85.54 199.51,85.66 199.51,86.88 199.39,87.01 199.13,87.01 199.01,86.88 199.01,85.66 198.88,85.54 198.62,85.54 198.5,85.66 198.5,86.88 198.37,87.01 198.12,87.01 197.99,86.88 197.99,85.66 197.86,85.54 197.61,85.54 197.48,85.66 197.48,86.88 197.35,87.01 197.1,87.01 196.97,86.88 196.97,85.66 196.85,85.54 196.59,85.54 196.47,85.66 196.47,86.88 196.34,87.01 196.08,87.01 195.96,86.88 195.96,85.66 195.83,85.54 195.58,85.54 195.45,85.66 195.45,86.88 195.32,87.01 195.07,87.01 194.94,86.88 194.94,85.66 194.81,85.54 194.56,85.54 194.43,85.66 194.43,86.88 194.31,87.01 194.05,87.01 193.93,86.88 193.93,85.66 193.8,85.54 193.54,85.54 193.42,85.66 193.42,86.88 193.29,87.01 193.04,87.01 192.91,86.88 192.91,85.66 192.78,85.54 192.51,85.54 190.27,87.77 184.68,87.77 184.48,87.98 184.48,89.65 184.94,90.11 188.29,90.11 188.44,90.26 188.44,90.92 188.06,91.3 187.79,91.3 v2(187.48,91.62)
  BOTTOM w0.127: RA17.8 179.82,97.23 181.15,95.9 181.15,94.99 181.46,94.68 183.29,94.68 183.69,94.27 183.69,93.54 183.97,93.26 184.4,93.26 186.36,91.3 187.16,91.3 v2(187.48,91.62)
MIPI_EMU19: length 78.9
  TOP w0.127: J19.53 v2(212.18,82.35)
  L03_SIG1 w0.127: v2(212.18,82.35) 211.77,81.93 206.25,81.93 205.66,82.51 203.4,82.51 200.69,85.23 190.51,85.23 190.38,85.36 190.38,87.21 190.26,87.34 190,87.34 189.87,87.21 189.87,85.36 189.75,85.23 189.49,85.23 189.37,85.36 189.37,87.21 189.24,87.34 188.99,87.34 188.86,87.21 188.86,85.36 188.73,85.23 188.48,85.23 188.35,85.36 188.35,87.21 188.22,87.34 187.97,87.34 187.84,87.21 187.84,85.36 187.72,85.23 187.46,85.23 187.33,85.36 187.33,87.21 187.21,87.34 186.95,87.34 186.83,87.21 186.83,85.36 186.7,85.23 186.45,85.23 186.32,85.36 186.32,87.21 186.19,87.34 185.94,87.34 185.81,87.21 185.81,85.36 185.68,85.23 185.43,85.23 185.3,85.36 185.3,87.21 185.18,87.34 184.92,87.34 184.79,87.21 184.79,85.36 184.67,85.23 184.4,85.23 183.82,85.82 183.82,90.44 184.16,90.78 v2(187.92,90.78)
  BOTTOM w0.127: RA17.7 180.47,97.12 182.5,95.09 183.72,95.09 184.89,93.92 184.89,93.31 186.08,92.12 187.7,92.12 188.23,91.58 188.23,91.09 v2(187.92,90.78)
MIPI_EMU_RTCK: length 4.4
  TOP w0.127: J19.7 223.68,83.07 223.27,83.49 R329.1
MIPI_RTCK: length 10.3
  TOP w0.127: v2(223.77,87.14) 223.27,86.63 R329.2 ; U132.16 v2(221.85,93.47)
  L03_SIG1 w0.127: v2(221.85,93.47) 221.85,92.85 223.15,91.55 223.15,87.76 v2(223.77,87.14)
MIPI_TCK: length 21.9
  TOP w0.127: v2(218.19,87.26) 218.44,87.26 218.85,87.67 U132.3 ; v2(213.36,87.39) R314.1 R326.2 ; R322.2 v2(226.31,87.14) ; v2(221.36,87.26) 221.35,87.28 U132.8
  BOTTOM w0.127: v2(226.31,87.14) 225.73,87.72 223.6,87.72 222.57,86.69 221.93,86.69 v2(221.36,87.26) 220.98,87.26 220.22,88.03 218.95,88.03 v2(218.19,87.26) 217.74,87.26 216.85,86.37 214.38,86.37 v2(213.36,87.39)
MIPI_TCK_R: length 4.9
  TOP w0.127: J19.3 224.68,83.14 226.25,84.71 R322.1
MIPI_TDI: length 9.8
  TOP w0.127: v2(219.07,86.37) 218.97,86.48 218.97,87.29 219.35,87.66 U132.4 ; R327.2 v2(224.79,87.26)
  BOTTOM w0.127: v2(224.79,87.26) 223.65,86.12 221.61,86.12 221.11,86.63 220.22,86.63 219.96,86.37 v2(219.07,86.37)
MIPI_TDI_R: length 4.5
  TOP w0.127: J19.5 224.18,84.04 224.79,84.65 R327.1
MIPI_TDO: length 2.7
  TOP w0.127: U133.3 v2(228.81,91.62)
  BOTTOM w0.127: R362.1 228.83,91.6 v2(228.81,91.62)
MIPI_TDO_R: length 34.2
  TOP w0.127: J19.4 224.68,68.89 224.92,68.66 v2(224.92,68.21)
  L03_SIG1 w0.127: v2(228.98,90.3) 229.29,89.98 229.44,89.98 231.39,88.03 231.39,85.82 230.71,85.13 229.51,85.13 225.68,81.29 225.68,68.98 v2(224.92,68.21)
  BOTTOM w0.127: v2(228.98,90.3) R362.2
MIPI_TMS: length 30
  TOP w0.127: v2(220.22,87.26) 220.35,87.39 U132.6 ; v2(225.42,67.32) 226.44,68.34 R358.1
  L08_SIG2 w0.127: v2(220.22,87.26) 220.73,87.77 222.38,87.77 226.11,84.04 226.11,80.7 223.29,77.88 223.29,70.58 225.42,68.44 v2(225.42,67.32)
MIPI_TMS_R: length 4.5
  TOP w0.127: J19.2 225.18,72.88 226.44,71.62 R358.2
MIPI_TRGRSTZ: length 33.7
  TOP w0.127: v2(222.12,87.26) 221.95,87.44 221.95,87.45 221.85,87.55 U132.9 ; R781.1 v2(222.63,68.34)
  L08_SIG2 w0.127: v2(222.63,68.34) 219.96,71.01 219.96,75 225.04,80.08 225.04,81.8 224.72,82.12 224.72,82.65 225.04,82.97 225.04,84.34 v2(222.12,87.26)
  BOTTOM w0.127: v2(222.12,87.26) 222.12,87.77 223.14,88.79 223.77,88.79 224.28,88.28 227.08,88.28 228.08,87.28 R904.2
MIPI_TRST#: length 28.1
  TOP w0.127: R364.1 v2(221.11,68.34) ; v2(219.46,87.14) 219.46,87.21 219.85,87.6 U132.5
  L08_SIG2 w0.127: v2(221.11,68.34) 219.33,70.12 219.33,74.82 224.8,80.29 224.8,81.7 224.48,82.02 224.48,82.86 224.8,83.17 224.8,84.03 222.2,86.63 219.96,86.63 v2(219.46,87.14)
MIPI_TRST#_R: length 5.2
  TOP w0.127: R364.2 221.85,71.64 222.38,71.64 223.68,72.95 J19.8
MLB_RSTN: length 226.6
  TOP w0.127: U106.1 129.17,25.05 128.73,24.6 v2(127.94,24.6) ; U35.14 92.42,173.33 92.58,173.5 93.22,173.5 93.47,173.24 v2(93.47,172.48) 93.6,172.35 R300.1
  L03_SIG1 w0.127: v2(127.94,24.6) 127.56,24.22 122.76,24.22 118.08,19.55 108.71,19.55 108.28,19.98 107.95,19.98 107.9,19.99 107.86,20.03 104.96,20.03 101.47,23.51 82.35,23.51 77.8,28.06 77.8,40.01 79.64,41.85 79.64,45.73 78.74,46.62 78.74,51.86 79.48,52.59 v2(79.48,59.07)
  BOTTOM w0.127: v2(79.48,59.07) 75.63,62.92 75.63,114.72 65.32,125.04 65.32,140.7 65.73,141.11 67.83,141.11 92.74,166.02 92.74,171.74 v2(93.47,172.48)
MLB_RSTN_AND: length 18.5
  TOP w0.127: J34.25 129.27,20.07 129.26,20.08 129.26,21.81 131.88,24.42 131.88,29.4 132.26,29.78 132.26,32.93 131.97,33.22 131.26,33.22 U140.4 R854.1
MODE: length 5.7
  TOP w0.127: U6.7 279.1,95.88 278.54,95.32 278.54,94.4 v2(278.36,94.22) 278.36,94.2 277.75,93.59 R75.2
  BOTTOM w0.127: R611.1 277.75,93.46 278.36,94.07 v2(278.36,94.22)
NRESPWRON2: length 246.5
  TOP w0.102: 76.78,202.55 76.78,202.45 76.43,202.1 76.43,201.78 76.43,200.94 76.43,200.94 U20.A13
  TOP w0.127: v1(76.78,203.01) 76.78,202.55 ; R248.1 R245.2 v2(259.22,182.75) ; U26.3 v2(99.31,178.82)
  L03_SIG1 w0.127: v2(156.34,186.45) 170.56,186.45 172.67,188.56 v2(172.67,192.47)
  L08_SIG2 w0.127: v2(95.12,181.12) 97.42,178.82 v2(99.31,178.82) 100.18,177.95 103.77,177.95 105.99,180.18 105.99,184.88 110.85,189.73 153.06,189.73 v2(156.34,186.45)
  BOTTOM w0.127: v1(76.78,203.01) 76.94,203.16 78.56,203.16 78.96,203.56 83.6,203.56 84.62,204.57 93.6,204.57 95.21,202.96 95.4,202.77 95.4,181.4 v2(95.12,181.12) ; v2(172.67,192.47) 172.85,192.65 172.85,199.79 175.01,201.94 196.29,201.94 209.42,188.81 216.61,188.81 218.95,191.15 250.57,191.15 251.84,189.88 251.84,187.59 256.68,182.75 v2(259.22,182.75)
OSCIN: length 9.5
  TOP w0.127: U17.L19 248.88,50.45 249.55,51.12 250.93,51.12 251.37,51.56 C60.1 252.4,51.56 253.25,52.42 255.86,52.42 255.97,52.31 Y2.3
OSCOUT: length 7
  TOP w0.127: U17.K19 248.58,51.6 249.86,51.6 251.53,53.27 C54.1 253.13,53.27 253.42,53.56 254.21,53.56 Y2.1
OSCVSS: length 25.9
  TOP w0.127: v2(250.8,51.63) 250.52,51.35 248.92,51.35 248.39,50.81 248.37,50.81 248.07,50.82 248.07,50.81 247.79,50.81 U17.L18
  TOP w0.381: 254.23,50.36 254.58,50 v2(254.99,50) ; 254.23,50.36 254.23,50.05 254.05,49.88 252.28,49.88 C60.2 ; 254.23,50.36 254.23,51.38 Y2.2 ; C54.2 v2(253.45,55.07) ; v2(255.97,54.76) 256.03,54.7 256.03,53.68 Y2.4
  L03_SIG1 w0.381: v2(255.97,54.76) 255.97,54.67 255.24,53.94 255.24,53.89 254.93,53.57 254.93,50.24 254.99,50.2 v2(254.99,50)
  BOTTOM w0.254: 254.21,54.31 254.67,54.76 v2(255.97,54.76) ; 254.21,54.31 R635.1 ; 254.21,54.31 v2(253.45,55.07)
  BOTTOM w0.381: v2(250.8,51.63) 251.69,50.74 254.25,50.74 v2(254.99,50)
PCI_CON_PORZ: length 27.5
  BOTTOM w0.127: R606.2 215.63,232.16 219.91,236.44 219.91,243.3 222.14,245.52 223.81,245.52 224.1,245.23 224.13,245.23 224.26,245.1 229.65,245.1 230.06,245.51 J44.2
PCI_PORZ_IN: length 10.2
  TOP w0.127: J44.1 228.85,248.05 228.34,247.54 224.88,247.54 224.88,247.54 224.84,247.54 224.84,247.54 224.03,247.54 223.89,247.39 U131.4 223.49,246.54 223.43,246.6 R855.1
PCI_PORZ_OUT: length 188.1
  TOP w0.127: U138.1 104.13,194.59 103.89,194.83 R884.1 v2(103.01,195.98)
  L03_SIG1 w0.127: v2(170.31,202.58) 163.07,195.34 103.65,195.34 v2(103.01,195.98)
  BOTTOM w0.127: v2(170.31,202.58) 171.5,203.77 188.62,203.77 189.08,204.23 189.08,215.66 192,218.58 210.57,218.58 211.99,217.16 235.84,217.16 239.39,220.72 239.39,232.17 240.36,233.14 240.36,239.87 237.26,242.97 J44.3
PCIE_CLKN_CML_100MHZ: length 144.9
  TOP w0.102: v1(178.81,128.21) U1.F2 ; v2(155.5,82.47) 155.17,82.8 154.44,82.8 154.19,82.55 R20.2
  BOTTOM w0.102: v2(155.5,82.47) 155.17,82.8 154.58,82.8 154.28,83.1 154.28,84.09 154.64,84.44 156.24,84.44 166.93,73.75 177.93,73.75 187.3,83.12 193.65,83.12 197.13,86.6 197.13,93.33 199.03,95.24 199.03,101.73 203.66,106.35 203.66,113.07 202.67,114.06 202.67,118.63 204.75,120.72 204.75,131.23 205.36,131.84 205.36,135.54 202.53,138.37 195.46,138.37 194.35,137.25 193.23,137.25 193.13,137.15 190.79,137.15 189.09,135.45 186.51,135.45 182.42,131.36 179.76,131.36 178.57,130.18 178.57,129.2 178.68,129.09 178.95,129.09 179.02,129.02 179.02,128.84 178.92,128.74 178.71,128.74 178.57,128.6 178.57,128.45 v1(178.81,128.21)
PCIE_CLKN_HCSL_100MHZ: length 224.1
  TOP w0.102: J5.A14 217.48,225.02 217.58,225.12 217.58,225.25 217.68,225.35 220.7,225.35 222.99,223.07 222.99,166.79 221.95,165.75 221.95,140.33 220.07,138.45 220.07,125.35 216.76,122.05 216.76,111.3 211.86,106.4 211.86,97.64 208.48,94.26 208.48,88.16 206.34,86.02 189.86,86.02 181.04,77.21 160.72,77.21 158.5,79.43 158.5,92.15 158,92.65 157.63,92.65 157.53,92.75 157.53,93.21 157.45,93.28 157.2,93.28 157.12,93.21 157.12,92.75 157.02,92.65 156.6,92.65 v2(156.39,92.86) 156.16,92.64 155.31,92.64 155.08,92.86 R891.2
  BOTTOM w0.102: v2(156.39,92.86) 156.19,92.67 155.15,92.67 155.08,92.74 R891.2
PCIE_CLKP_CML_100MHZ: length 144.8
  TOP w0.102: R19.2 154.19,83.36 154.43,83.13 155.17,83.13 v2(155.5,83.45) ; v1(178.01,128.21) U1.G2
  BOTTOM w0.102: v2(155.5,83.45) 155.17,83.13 154.72,83.13 154.61,83.24 154.61,83.95 154.77,84.11 156.1,84.11 166.79,73.42 178.06,73.42 187.44,82.79 193.79,82.79 197.46,86.47 197.46,93.2 199.36,95.1 199.36,101.59 203.99,106.21 203.99,113.21 203,114.2 203,118.5 205.08,120.58 205.08,131.09 205.69,131.7 205.69,135.68 202.67,138.7 195.33,138.7 194.21,137.58 193.09,137.58 192.99,137.48 190.65,137.48 188.95,135.78 186.38,135.78 182.29,131.69 179.62,131.69 178.24,130.31 178.24,128.45 v1(178.01,128.21)
PCIE_CLKP_HCSL_100MHZ: length 224.2
  TOP w0.102: R890.2 155.08,92.04 155.34,92.31 156.16,92.31 v2(156.39,92.08) 156.62,92.32 157.86,92.32 158.17,92.01 158.17,79.29 160.58,76.88 181.18,76.88 189.99,85.69 206.48,85.69 208.81,88.03 208.81,94.12 212.19,97.5 212.19,106.26 217.09,111.17 217.09,121.91 220.4,125.21 220.4,138.32 222.28,140.2 222.28,165.61 223.32,166.65 223.32,223.2 220.84,225.69 217.68,225.69 217.58,225.79 217.58,225.92 217.48,226.02 J5.A13
  BOTTOM w0.102: v2(156.39,92.08) 156.15,92.32 155.19,92.32 155.08,92.21 R890.2
PCIEI_RSTN: length 190.6
  TOP w0.127: R288.1 92.56,173.88 92.52,173.91 v2(92.08,173.91) 91.92,173.76 U35.15 ; R65.1 v2(219.14,241.25)
  L03_SIG1 w0.127: v2(219.14,241.25) 219.14,239.89 219.53,239.5 219.53,237.33 218.96,236.76 216.88,236.76 216.12,237.52 203.32,237.52 202.74,236.94 202.74,235.12 202.87,234.99 202.87,232.44 204.02,231.28 205.19,231.28 207.63,228.84 207.63,227.81 206.73,226.91 206.73,222.41 197.44,213.12 182.56,213.12 179.83,210.39 179.83,204.36 177.69,202.21 177.67,202.21 177.53,202.07 173.85,202.07 164.19,192.42 123.65,192.42 123.19,191.96 97.73,191.96 93.85,188.09 93.85,186.07 92.63,184.85 92.63,183.61 92.96,183.28 92.96,180.99 93.47,180.48 93.47,179.85 92.08,178.45 v2(92.08,173.91)
PGD: length 38.5
  TOP w0.127: R925.1 R924.1 v2(254.51,226.33)
  L08_SIG2 w0.254: v2(254.51,226.33) 260.99,226.33 264.67,222.65 276.22,222.65 280.67,218.2 280.67,213.76 280.8,213.63 v2(280.8,213.12)
  BOTTOM w0.127: U149.8 v2(280.8,213.12)
PHY1_LED_ACTN: length 51
  TOP w0.127: U92.17 177.41,50.88 177.75,51.21 R528.1 180.66,51.21 v2(180.72,51.15) ; v2(184,33.24) 182.55,31.79 182.55,14.49 181.41,13.35 J31.12
  L03_SIG1 w0.127: v2(184,33.24) 184,40.68 181.53,43.14 181.53,50.33 v2(180.72,51.15)
  BOTTOM w0.127: v2(180.72,51.15) 180.66,51.21 R528.1
PHY1_LED_LINKN: length 69.4
  TOP w0.127: U92.15 177.41,49.88 v2(177.91,50.38) ; v2(183.03,33.11) 179.55,29.63 158.27,29.63 156.46,27.83 156.46,19.7 160.78,15.38 J31.13 ; R530.1 v2(177.34,48.15)
  L03_SIG1 w0.127: v2(177.34,48.15) 177.79,48.15 178.44,48.8 178.44,49.86 v2(177.91,50.38)
  BOTTOM w0.127: v2(183.03,33.11) 183.03,34.61 179.55,38.09 179.55,42.18 178.84,42.89 178.84,47.65 R530.1 v2(177.34,48.15)
PLL0_VDDA1V2: length 23.2
  TOP w0.254: U17.L15 v1(245.42,50.05)
  TOP w0.381: FL13.2 245.34,36.64 v2(245.34,37.78)
  BOTTOM w0.127: C79.2 248.77,51.62 248.33,52.05 245.24,52.05 245.02,51.83 245.02,51.07 C416.1 244.82,50.65 v1(245.42,50.05)
  BOTTOM w0.381: v2(245.34,37.78) 246.48,37.78 247.37,38.67 247.37,42.36 244.7,45.02 244.7,49.29 245.22,49.8 245.22,49.84 v1(245.42,50.05)
PLL0_VSSA: length 19
  TOP w0.127: U17.M17 v1(247.02,49.25) 248.93,49.25 249.02,49.34 249.53,49.34 249.91,48.96 249.91,48.83 250.29,48.45 250.95,48.45
  TOP w0.381: FL14.2 257.78,46.68 255.66,48.8 251.83,48.8 251.8,48.77 251.63,48.77 251.31,48.45 250.95,48.45
  BOTTOM w0.127: C416.2 246.23,50.87 246.63,50.46 246.63,50.31 246.63,50.3 246.63,49.64 v1(247.02,49.25)
  BOTTOM w0.381: C79.1 248.77,50.1 247.98,49.32 247.49,49.32 247.42,49.25 v1(247.02,49.25)
PLL1_VDDA1V2: length 18.8
  TOP w0.254: U17.N15 v1(245.42,48.45)
  TOP w0.381: FL16.2 247.88,37.02 v2(248.64,37.78)
  BOTTOM w0.381: v1(245.42,48.45) 245.42,47.11 247,45.53 C94.2 247.1,44.53 247.5,44.13 249.15,44.13 250.16,43.12 250.16,39.31 v2(248.64,37.78) 249.43,37 C459.1
