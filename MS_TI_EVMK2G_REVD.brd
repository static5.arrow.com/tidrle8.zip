# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Nets (continued)
DGND: C1.2 C2.2 C3.1 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.1 C13.2 C15.2 C16.2 C17.1 C18.1 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.1 C26.2 C28.1 C30.1 C31.2 C32.2 C33.1 C34.1 C35.2 C36.2 C37.2 C38.2 C39.2 C40.1 C41.1 C42.2 C43.2 C44.1 C45.1 C46.1 C47.1 C48.2 C49.2 C50.2 C51.2 C55.1 C56.1 C57.1 C58.1 C59.1 C61.1 C62.1 C63.2 C64.2 C65.1 C66.2 C67.1 C68.1 C69.2 C70.2 C71.1 C73.2 C74.2 C75.2 C76.2 C78.2 C81.2 C82.2 C83.2 C84.2 C85.1 C86.1 C87.1 C88.1 C89.1 C90.1 C91.2 C92.2 C93.2 C95.2 C96.2 C97.2 C98.2 C99.1 C100.2 C101.2 C102.2 C103.1 C105.2 C106.1 C107.2 C108.2 C109.2 C110.1 C111.1 C112.1 C113.2 C114.1 C117.2 C118.1 C122.2 C123.1 C124.1 C125.1 C126.1 C129.1 C130.1 C131.1 C133.2 C134.2 C135.2 C136.1 C137.1 C138.1 C140.1 C141.1 C142.1 C143.2 C144.2 C145.2 C146.2 C147.2 C148.1 C149.1 C150.1 C154.1 C155.1 C156.2 C159.2 C162.1 C165.1 C166.2 C167.2 C168.2 C169.2 C172.2 C173.2 C174.1 C175.2 C176.2 C177.2 C178.1 C179.1 C180.2 C181.2 C182.2 C183.2 C184.2 C185.1 C187.1 C188.2 C189.2 C190.1 C191.2 C192.1 C193.2 C194.2 C195.2 C196.2 C197.2 C198.1 C199.1 C200.2 C201.2 C202.2 C203.1 C204.2 C205.2 C206.2 C207.2 C208.1 C209.1 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C221.2 C222.2 C224.1 C225.1 C226.2 C227.2 C228.1 C229.1 C230.1 C231.1 C233.2 C235.2 C236.2 C237.2 C238.2 C239.1 C240.2 C242.1 C243.2 C244.1 C246.1 C247.2 C248.1 C249.2 C250.2 C251.2 C252.1 C253.1 C254.2 C255.2 C256.2 C257.2 C258.2 C259.1 C260.1 C261.1 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.1 C269.2 C271.2 C272.1 C273.2 C274.2 C276.2 C277.2 C278.2 C279.1 C280.2 C282.2 C283.1 C284.2 C286.2 C287.1 C288.1 C290.2 C291.2 C292.2 C293.1 C294.1 C295.1 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C310.2 C311.2 C312.2 C313.2 C314.2 C315.2 C316.2 C317.2 C318.1 C319.2 C320.1 C321.2 C322.1 C323.2 C324.2 C325.2 C326.2 C327.2 C329.2 C330.2 C331.2 C333.2 C334.1 C335.1 C336.2 C337.2 C338.2 C340.2 C341.2 C342.2 C346.2 C348.2 C349.1 C350.2 C351.1 C354.1 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.2 C370.2 C371.2 C372.2 C373.1 C374.2 C375.2 C376.1 C377.1 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C386.2 C387.1 C388.2 C389.1 C390.1 C392.2 C393.1 C395.1 C396.1 C397.1 C399.1 C400.2 C401.1 C403.2 C404.2 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.2 C413.2 C414.2 C415.1 C417.2 C418.1 C419.1 C420.2 C421.1 C422.1 C423.1 C424.1 C425.1 C426.1 C427.1 C429.2 C430.2 C431.2 C432.2 C433.2 C434.2 C435.2 C436.1 C437.2 C438.2 C439.2 C440.1 C441.2 C442.2 C443.2 C444.2 C445.2 C446.1 C447.2 C448.2 C449.2 C450.2 C453.2 C454.2 C455.1 C456.2 C458.2 C460.1 C461.2 C462.2 C463.1 C464.1 C465.2 C467.1 C468.2 C470.2 C471.1 C473.1 C474.2 C475.2 C477.2 C478.2 C479.1 C480.2 C481.2 C482.2 C483.1 C484.1 C485.2 C486.1 C487.1 C488.2 C489.2 C490.2 C491.2 C492.2 C493.1 C494.2 C495.2 C496.2 C498.2 C500.1 C501.2 C502.2 C503.2 C506.2 C507.2 C508.2 C509.2 C510.1 C511.2 C512.2 C513.2 C514.2 C515.2 C516.2 C517.2 C518.2 C519.2 C520.2 C521.1 C522.2 C523.2 C524.2 C525.1 C527.2 C528.2 C529.2 C530.2 C531.2 C532.2 C533.2 C534.1 C535.1 C536.1 C537.1 C538.2 C539.2 C540.1 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.1 C555.2 C556.2 C557.1 C558.2 C559.2 C560.2 C561.1 C562.2 C563.2 C564.2 C565.1 C566.1 C567.2 C568.2 C569.2 C570.2 C571.2 C572.2 C573.2 C574.1 C575.2 C576.2 C577.2 C578.1 C579.2 C580.2 C581.2 C582.2 C583.2 C584.2 C585.2 C586.2 C587.1 C588.2 C589.2 C590.2 C591.1 C592.2 C593.1 C594.2 C595.1 C596.1 C597.1 C598.1 C599.1 C600.2 C601.1 C602.2 C603.2 C604.2 C605.2 C606.2 C607.2 C608.2 C609.1 C610.1 C611.1 C612.2 C613.2 C614.1 C615.2 C616.2 C617.1 C618.2 C619.1 C620.1 C621.1 C622.2 C623.1 C624.1 C625.1 C626.2 C627.2 C628.2 C630.2 C631.2 C632.2 C633.2 C634.2 C635.2 C637.2 C638.1 C639.2 C641.2 C642.2 C643.2 C645.1 C646.2 C647.2 C648.1 C649.1 C650.1 C651.2 C652.2 C653.1 C654.1 C655.2 C656.2 C657.1 C659.1 C661.2 C663.2 C665.1 C666.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.1 C673.2 C674.2 C675.1 C676.1 C677.2 C678.2 C679.2 C681.2 C683.2 C684.2 C685.2 C686.2 C689.2 C690.2 C692.1 C693.2 C694.2 C697.2 C698.2 C699.2 C700.2 C701.2 C703.1 C704.1 C706.1 C707.2 C708.2 C709.2 C710.1 C711.1 C712.2 C713.1 C715.2 C717.1 C718.2 C720.1 C721.2 C723.1 C724.2 C726.2 C733.1 C734.2 C735.2 C737.2 C738.2 C739.2 C740.2 C741.2 C742.2 C744.2 C745.2 C746.2 C749.2 C750.2 C752.2 C754.2 C756.1 C757.2 C758.1 C759.1 C760.2 C761.1 C762.2 C763.1 C775.2 C776.2 C777.2 C778.2 C780.1 C781.1 C782.1 C783.1 C784.1 C785.1 C786.2 C789.1 C790.1 C791.2 C792.2 C793.2 C794.2 C795.2 C796.2 C797.2 C798.2 C799.2 C800.1 C801.2 C802.2 C803.2 C804.2 C807.2 C808.2 C809.2 C810.2 C811.2 C812.1 C813.2 C815.2 C816.2 C817.2 C818.2 C819.2 C820.2 C821.2 C822.2 C824.2 C825.2 C826.2 C827.2 D2.5(ANODE) D5.2(ANODE) D6.2(A) D7.2(A) D8.2(A) D9.2(A) D10.2(A) D11.2(A) D12.2(A) D13.2(A) D14.3(GND) D15.3(GND) D17.2(ANODE) D18.2(ANODE) D19.2(A) FB1.1 FB13.2 FB15.1 FB33.2 FB34.2 FB41.2 FB42.1 FB43.1 FB44.1 FB46.1 FL2.1 FL3.2(GND) FL5.2(GND) FL7.2 FL8.2 FL9.2 FL14.1 FL15.1 J1.5(GND) J2.2 J2.3 J2.6 J2.9 J2.18 J2.19 J2.22 J2.37 J2.42 J2.47 J2.60 J2.63 J2.64 J2.77 J2.83 J2.87 J2.92 J2.95 J2.97 J3.2 J3.3 J4.6 J5.A4 J5.A12 J5.A15 J5.A18 J5.B4 J5.B7 J5.B13 J5.B16 J5.B18 J6.2 J7.4 J7.8 J7.10 J7.12 J8.4 J8.8 J8.10 J8.12 J8.16 J8.20 J9.3 J10.2 J11.3 J12.5 J12.6 J12.7 J12.8 J12.17 J12.20 J12.26 J12.31 J12.32 J12.40 J12.43 J12.44 J12.48 J12.49 J12.50 J17.1 J18.3 J19.16 J19.57 J21.2 J21.7 J21.8 J22.3 J22.29 J22.36 J23.5(GND) J31.1(CH-GND) J34.41(GND1) J34.42(GND2) J34.43(GND3) J34.44(GND4) J35.4 J36.2 J36.5 J36.8 J36.11 J36.17 J37.6(VSS) J37.12(CD2) J38.5(GND) J49.1 JP1.1 JP1.3 JP1.5 JP1.7 JP1.8 JP1.13 JP1.14 JP1.19 JP1.20 JP1.25 JP1.26 JP1.31 JP1.32 JP1.37 JP1.38 JP1.43 JP1.44 JP1.49 JP1.50 JP1.55 JP1.56 JP1.61 JP1.62 JP1.67 JP1.68 JP1.73 JP1.74 JP1.79 JP1.80 JP1.84 JP1.85 JP1.86 JP1.91 JP1.95 JP1.96 JP1.99 JP1.100 LD6.1 LD9.1 MOD1.11(VSS) MOD1.K P1.5 Q6.2(S) Q7.2(S) Q8.2(S) Q9.2(S) Q10.2(S) Q11.2(S) Q12.2(S) Q14.2(S) Q15.2(S) Q19.2(S) R2.2 R4.2 R5.1 R34.1 R35.1 R36.2 R37.2 R40.1 R44.2 R45.2 R68.2 R71.2 R73.2 R75.1 R78.2 R79.2 R84.2 R95.1 R96.2 R97.2 R98.2 R99.2 R107.1 R108.1 R115.1 R131.1 R152.1 R157.1 R165.1 R176.1 R184.1 R191.1 R198.1 R218.2 R226.2 R228.1 R229.1 R244.2 R252.2 R259.1 R262.1 R263.1 R272.1 R283.1 R302.1 R312.1 R315.2 R318.2 R319.1 R342.1 R347.1 R349.1 R354.1 R385.1 R386.1 R426.2 R431.1 R438.2 R440.1 R442.1 R443.1 R455.2 R474.2 R479.2 R483.2 R487.2 R490.1 R494.2 R499.1 R502.1 R515.2 R517.1 R522.2 R523.1 R528.2 R535.1 R548.2 R563.2 R567.2 R571.1 R572.1 R573.1 R574.1 R575.1 R576.1 R584.1 R597.2 R598.2 R599.2 R604.2 R625.1 R626.2 R630.2 R635.2 R637.1 R638.1 R642.1 R647.2 R651.1 R652.2 R653.1 R654.1 R655.1 R657.1 R658.1 R672.1 R677.1 R683.1 R684.1 R686.1 R689.1 R690.1 R693.1 R696.1 R697.2 R699.1 R701.2 R702.1 R704.1 R712.1 R717.1 R718.1 R719.2 R720.2 R722.1 R724.2 R727.1 R730.2 R732.2 R734.2 R736.1 R737.1 R738.2 R744.1 R748.1 R752.2 R753.2 R754.2 R756.1 R757.2 R758.2 R763.2 R764.2 R765.2 R768.2 R771.1 R782.2 R783.1 R785.1 R786.2 R787.1 R793.1 R808.1 R812.2 R825.1 R827.2 R829.1 R833.2 R834.1 R836.1 R839.1 R840.1 R841.1 R846.1 R848.1 R850.1 R864.1 R867.2 R868.2 R872.1 R873.2 R887.2 R889.1 R899.1 R901.1 R902.2 R903.2 R911.1 R913.1 R915.1 R920.2 R921.2 RA16.1 RA16.2 RA16.3 RA16.4 SW2.3(B1) SW2.4(B2) SW4.3(B1) SW4.4(B2) SW5.3(B1) SW5.4(B2) SW6.3(B1) SW6.4(B2) SW7.3(B1) SW7.4(B2) SW9.3(B1) SW9.4(B2) SW10.3(B1) SW10.4(B2) TP51.1(TP) TP53.1(TP) TP61.1(TP) TP62.1(TP) TP90.1(TP) TP92.1(TP) TP104.1(TP) TP129.1(TP) TP201.1(TP) TP202.1(TP) TP203.1(TP) TP204.1(TP) U1.A1(VSS#A1) U1.A25(VSS#A25) U1.AD8(VSS#AD8) U1.AD14(VSS#AD14) U1.AE1(VSS#AE1) U1.AE5(VSS#AE5) U1.AE11(VSS#AE11) U1.AE18(VSS#AE18) U1.AE25(VSS#AE25) U1.C1(VSS#C1) U1.E2(VSS#E2) U1.E22(VSS#E22) U1.F1(VSS#F1) U1.F3(VSS#F3) U1.F6(VSS#F6) U1.F8(VSS#F8) U1.F20(VSS#F20) U1.G7(VSS#G7) U1.G9(VSS#G9) U1.G11(VSS#G11) U1.G13(VSS#G13) U1.G15(VSS#G15) U1.G17(VSS#G17) U1.G19(VSS#G19) U1.G21(VSS#G21) U1.H6(VSS#H6) U1.H8(VSS#H8) U1.H10(VSS#H10) U1.H12(VSS#H12) U1.H14(VSS#H14) U1.H16(VSS#H16) U1.H18(VSS#H18) U1.H20(VSS#H20) U1.J1(VSS#J1) U1.J7(VSS#J7) U1.J9(VSS#J9) U1.J11(VSS#J11) U1.J13(VSS#J13) U1.J15(VSS#J15) U1.J17(VSS#J17) U1.J19(VSS#J19) U1.K6(VSS#K6) U1.K8(VSS#K8) U1.K10(VSS#K10) U1.K12(VSS#K12) U1.K14(VSS#K14) U1.K16(VSS#K16) U1.K18(VSS#K18) U1.K20(VSS#K20) U1.L7(VSS#L7) U1.L9(VSS#L9) U1.L11(VSS#L11) U1.L13(VSS#L13) U1.L15(VSS#L15) U1.L17(VSS#L17) U1.L19(VSS#L19) U1.M6(VSS#M6) U1.M8(VSS#M8) U1.M10(VSS#M10) U1.M12(VSS#M12) U1.M14(VSS#M14) U1.M16(VSS#M16) U1.M18(VSS#M18) U1.M20(VSS#M20) U1.N7(VSS#N7) U1.N9(VSS#N9) U1.N11(VSS#N11) U1.N13(VSS#N13) U1.N15(VSS#N15) U1.N17(VSS#N17) U1.N19(VSS#N19) U1.N21(VSS#N21) U1.P6(VSS#P6) U1.P8(VSS#P8) U1.P10(VSS#P10) U1.P12(VSS#P12) U1.P14(VSS#P14) U1.P16(VSS#P16) U1.P18(VSS#P18) U1.P20(VSS#P20) U1.R7(VSS#R7) U1.R9(VSS#R9) U1.R11(VSS#R11) U1.R13(VSS#R13) U1.R15(VSS#R15) U1.R17(VSS#R17) U1.R19(VSS#R19) U1.R23(VSS#R23) U1.T6(VSS#T6) U1.T8(VSS#T8) U1.T10(VSS#T10) U1.T12(VSS#T12) U1.T14(VSS#T14) U1.T16(VSS#T16) U1.T18(VSS#T18) U1.T20(VSS#T20) U1.U7(VSS#U7) U1.U9(VSS#U9) U1.U11(VSS#U11) U1.U13(VSS#U13) U1.U15(VSS#U15) U1.U17(VSS#U17) U1.U19(VSS#U19) U1.V8(VSS#V8) U1.V10(VSS#V10) U1.V12(VSS#V12) U1.V14(VSS#V14) U1.V16(VSS#V16) U1.V18(VSS#V18) U1.V20(VSS#V20) U1.W7(VSS#W7) U1.W9(VSS#W9) U1.W11(VSS#W11) U1.W13(VSS#W13) U1.W15(VSS#W15) U1.W17(VSS#W17) U1.Y10(VSS#Y10) U1.Y23(VSS#Y23) U2.2(GND) U4.3(GND) U5.3(GND) U6.4(PGND) U6.10(AGND) U6.17(EP) U7.6(GND) U7.9(PAD) U8.6(GND) U8.9(PAD) U9.A1(VSS#A1) U9.A3(VSSQ#A3) U9.B7(VSSQ#B7) U9.C3(VSSQ#C3) U9.D7(VSSQ#D7) U9.E3(VSS#E3) U9.J1(VSS#J1) U10.2(GND) U11.4(GND) U12.4(GND#4) U12.17(GND#17) U12.25(GND#25) U13.14(GND) U14.4(GND) U16.4(GND) U17.A19(VSS#A19) U17.H1(VSS#H1) U17.H2(VSS#H2) U17.H8(VSS#H8) U17.H9(VSS#H9) U17.H15(VSS#H15) U17.J7(VSS#J7) U17.J8(VSS#J8) U17.J9(VSS#J9) U17.J10(VSS#J10) U17.J11(VSS#J11) U17.K1(VSS#K1) U17.K2(VSS#K2) U17.K7(VSS#K7) U17.K8(VSS#K8) U17.K9(VSS#K9) U17.K10(VSS#K10) U17.K11(VSS#K11) U17.L3(VSS#L3) U17.L5(VSS#L5) U17.L7(VSS#L7) U17.L8(VSS#L8) U17.L9(VSS#L9) U17.L10(VSS#L10) U17.L11(VSS#L11) U17.M1(VSS#M1) U17.M4(VSS#M4) U17.M5(VSS#M5) U17.M6(VSS#M6) U17.M7(VSS#M7) U17.M10(VSS#M10) U17.M11(VSS#M11) U17.N5(VSS#N5) U17.N11(VSS#N11) U17.N12(VSS#N12) U17.P11(VSS#P11) U18.2(GND1) U18.3(GND2) U18.15(PAD) U20.A1(GND#A1) U20.A2(GND#A2) U20.A18(GND#A18) U20.A19(GND#A19) U20.B1(GND#B1) U20.B19(GND#B19) U20.F10(GND#F10) U20.G4(GNDA) U20.G5(VREFA-) U20.H10(GND#H10) U20.H11(GND#H11) U20.H12(GND#H12) U20.J11(GND#J11) U20.J12(GND#J12) U20.K6(GND#K6) U20.K9(GND#K9) U20.K10(GND#K10) U20.K13(GND#K13) U20.K14(GND#K14) U20.L8(GND#L8) U20.L9(GND#L9) U20.M8(GND#M8) U20.M9(GND#M9) U20.M10(GND#M10) U20.N10(GND#N10) U20.P16(GND#P16) U20.R17(GND#R17) U20.R18(GNDX) U20.V1(GND#V1) U20.W1(GND#W1) U20.W2(GND#W2) U21.2(GND) U22.9(EP) U23.2(GND) U24.11(GND1) U24.12(GND2) U24.13(GND3) U24.25(EP) U25.1(GND) U25.9(PAD) U26.2(GND) U27.A1(VSS#A1) U27.A8(VSS#A8) U27.B1(VSS#B1) U27.B2(VSSQ#B2) U27.B8(VSSQ#B8) U27.C9(VSSQ#C9) U27.D1(VSSQ#D1) U27.D8(VSS#D8) U27.D9(VSSQ#D9) U27.F2(VSS#F2) U27.F8(VSS#F8) U27.J1(VSS#J1) U27.J9(VSS#J9) U27.L1(VSS#L1) U27.L9(VSS#L9) U27.N1(VSS#N1) U27.N9(VSS#N9) U29.C4(VSSQ1) U29.D4(NC33) U29.E7(VSS1) U29.G5(VSS2) U29.H10(VSS3) U29.K8(VSS4) U29.N1(NC89) U29.N2(VSSQ2) U29.N5(VSSQ3) U29.P4(VSSQ4) U29.P6(VSSQ5) U30.8(GND1) U30.9(GND2) U31.8(GND1) U31.9(GND2) U32.A1(DGND_C) U32.A7(GND_CTRL_B) U32.A8(GND_CTRL_A) U32.B1(DGND_B) U32.B2(DGND_A) U32.C1(GND1_C) U32.C2(GND1_B) U32.D3(GND1_A) U32.J1(GND2_B) U32.J2(GND2_A) U32.J7(GNDIO_B) U32.J8(GNDIO_A) U33.11(GND1) U33.12(GND2) U33.13(GND3) U33.25(EP) U34.2(GND) U35.11(GND1) U35.12(GND2) U35.13(GND3) U35.25(EP) U36.3(GND) U37.8(GND) U38.4(GND) U39.A1(VSS#A1) U39.A8(VSS#A8) U39.B1(VSS#B1) U39.B2(VSSQ#B2) U39.B8(VSSQ#B8) U39.C9(VSSQ#C9) U39.D1(VSSQ#D1) U39.D8(VSS#D8) U39.D9(VSSQ#D9) U39.F2(VSS#F2) U39.F8(VSS#F8) U39.J1(VSS#J1) U39.J9(VSS#J9) U39.L1(VSS#L1) U39.L9(VSS#L9) U39.N1(VSS#N1) U39.N9(VSS#N9) U40.10(VSS) U41.11(GND1) U41.12(GND2) U41.13(GND3) U41.25(EP) U42.1(A1) U42.2(A0) U42.7(GND) U43.1(A1) U43.7(GND) U44.1(A1) U44.7(GND) U45.A1(VSS#A1) U45.A8(VSS#A8) U45.B1(VSS#B1) U45.B2(VSSQ#B2) U45.B8(VSSQ#B8) U45.C9(VSSQ#C9) U45.D1(VSSQ#D1) U45.D8(VSS#D8) U45.D9(VSSQ#D9) U45.F2(VSS#F2) U45.F8(VSS#F8) U45.J1(VSS#J1) U45.J9(VSS#J9) U45.L1(VSS#L1) U45.L9(VSS#L9) U45.N1(VSS#N1) U45.N9(VSS#N9) U46.1(A1) U46.7(GND) U47.3(GND) U48.2(A0) U48.7(GND) U49.A1(VSS#A1) U49.A8(VSS#A8) U49.B1(VSS#B1) U49.B2(VSSQ#B2) U49.B8(VSSQ#B8) U49.C9(VSSQ#C9) U49.D1(VSSQ#D1) U49.D8(VSS#D8) U49.D9(VSSQ#D9) U49.F2(VSS#F2) U49.F8(VSS#F8) U49.J1(VSS#J1) U49.J9(VSS#J9) U49.L1(VSS#L1) U49.L9(VSS#L9) U49.N1(VSS#N1) U49.N9(VSS#N9) U50.2(GND) U50.5(EP) U51.9(GND) U51.25(PAD) U52.A1(VSS#A1) U52.A8(VSS#A8) U52.B1(VSS#B1) U52.B2(VSSQ#B2) U52.B8(VSSQ#B8) U52.C9(VSSQ#C9) U52.D1(VSSQ#D1) U52.D8(VSS#D8) U52.D9(VSSQ#D9) U52.F2(VSS#F2) U52.F8(VSS#F8) U52.J1(VSS#J1) U52.J9(VSS#J9) U52.L1(VSS#L1) U52.L9(VSS#L9) U52.N1(VSS#N1) U52.N9(VSS#N9) U53.4(GND) U53.8(PGND) U53.11(PAD) U54.1(GND) U56.2(GND) U57.1(GND) U58.3(GND) U59.2(GND) U60.4(GND) U62.9(PRI_REFN) U62.49(EP) U64.8(GND1) U64.9(GND2) U66.3(GND) U67.4(GND#4) U67.10(GND#10) U67.15(GND#15) U67.21(GND#21) U67.28(GND#28) U67.34(GND#34) U67.39(GND#39) U67.45(GND#45) U68.3(GND) U69.8(GND1) U69.9(GND2) U71.3(GND) U72.10(VSS) U73.4(GND) U74.2(GND) U74.25(EP) U75.2(GND) U76.3(GND) U78.4(GND) U79.8(GND) U80.3(GND) U81.B3(GND#B3) U81.B4(GND#B4) U81.D3(GND#D3) U81.D4(GND#D4) U81.E3(GND#E3) U81.E4(GND#E4) U81.G3(GND#G3) U81.G4(GND#G4) U81.K3(GND#K3) U81.K4(GND#K4) U81.M3(GND#M3) U81.M4(GND#M4) U81.N3(GND#N3) U81.N4(GND#N4) U81.R3(GND#R3) U81.R4(GND#R4) U82.B3(GND#B3) U82.B4(GND#B4) U82.D3(GND#D3) U82.D4(GND#D4) U82.E3(GND#E3) U82.E4(GND#E4) U82.G3(GND#G3) U82.G4(GND#G4) U82.K3(GND#K3) U82.K4(GND#K4) U82.M3(GND#M3) U82.M4(GND#M4) U82.N3(GND#N3) U82.N4(GND#N4) U82.R3(GND#R3) U82.R4(GND#R4) U84.3(GND) U86.3(GND) U87.13(VSS1) U87.25(VSS2) U87.36(VSS3) U87.48(VSS4) U88.3(GND) U89.3(GND) U90.3(GND#3) U90.8(GND#8) U91.3(GND) U92.13(NC1) U92.29(VSS) U92.49(PADDLE_GND) U93.15(GND) U94.3(GND#3) U94.8(GND#8) U95.4(GND) U96.42(DVSS) U96.43(SELECT) U97.3(GND) U98.4(GND1) U100.4(GND1) U101.3(GND) U102.43(CGND) U102.55(RSVDL) U102.57(IOGND) U102.63(AGND) U102.70(VDDQ) U102.73(PAD) U103.2(GND) U106.3(GND) U107.4(GND) U108.6(GND1) U108.14(GND2) U108.19(GND3) U109.4(GND) U111.5(GND) U112.2(GND) U115.11(GND1) U115.12(GND2) U115.13(GND3) U115.25(EP) U116.4(GND) U116.7(PGND1) U116.8(PGND2) U116.17(EP) U118.1(-VIN) U119.1(-VIN) U122.2(GND) U123.B1(GND) U124.3(GND) U125.8(GND1) U125.9(GND2) U126.8(GND1) U126.9(GND2) U127.3(GND) U128.8(GND1) U128.9(GND2) U129.3(GND) U130.3(GND) U131.3(GND) U132.11(GND1) U132.12(GND2) U132.13(GND3) U132.25(EP) U133.8(GND) U134.8(GND) U135.2(GND) U136.8(GND1) U136.9(GND2) U137.2(GND) U138.2(GND) U139.3(GND) U140.3(GND) U141.4(GND) U141.7(PGND1) U141.8(PGND2) U141.17(EP) U142.11(GND) U144.3(GND) U146.3(GND) U147.3(GND) U149.6(GND) Y8.2 Y8.4
DVDD18: C177.1 C225.2 C229.2 C244.2 C597.2 C600.1 C722.2 FB17.1 FB19.1 FB20.1 FB21.1 FB23.1 FB24.1 FB25.1 FB27.1 FB28.1 FB29.1 J42.2 R381.1 U1.F17(DVDD18#F17) U1.F19(DVDD18/USB_LDO) U1.G6(DVDD18/PCIE_LDO) U1.J6(DVDD18#J6) U1.K19(DVDD18#K19) U1.L6(DVDD18#L6) U1.L20(DVDD18#L20) U1.M7(DVDD18#M7) U1.U6(DVDD18#U6) U1.U18(DVDD18#U18) U1.V19(DVDD18#V19) U1.W6(DVDD18#W6) U46.9(VIN-)
DVDD33: C178.2 C179.2 C185.2 C187.2 C197.1 C224.2 C231.2 C242.2 C243.1 C252.2 C253.2 C534.2 C538.1 C539.1 C550.1 C564.1 C585.1 C588.1 C596.2 C609.2 C613.1 C614.2 C615.1 C616.1 C617.2 C621.2 C714.2 J39.2 R359.1 U1.AA23(DVDD33#AA23) U1.E23(DVDD33#E23) U1.F7(DVDD33#F7) U1.F11(DVDD33#F11) U1.F15(DVDD33#F15) U1.F21(DVDD33#F21) U1.G12(DVDD33#G12) U1.G16(DVDD33#G16) U1.G18(DVDD33_USB#G18) U1.G20(DVDD33#G20) U1.H9(DVDD33#H9) U1.H11(DVDD33#H11) U1.H13(DVDD33#H13) U1.H15(DVDD33#H15) U1.H17(DVDD33_USB#H17) U1.J20(DVDD33#J20) U1.P7(DVDD33#P7) U1.P19(DVDD33#P19) U1.R6(DVDD33#R6) U1.R20(DVDD33#R20) U1.T7(DVDD33#T7) U1.T19(DVDD33#T19) U1.T23(DVDD33#T23) U1.U20(DVDD33#U20) U1.V21(DVDD33#V21) U42.9(VIN-)
DVDD_DDR: C198.2 C199.2 C202.1 C203.2 C208.2 C209.2 C212.1 C226.1 C227.1 C230.2 C565.2 C566.2 C573.1 C574.2 C576.1 C595.2 C598.2 C601.2 C725.2 J43.2 R383.1 U1.AD5(DVDD_DDR#AD5) U1.AD11(DVDD_DDR#AD11) U1.AD18(DVDD_DDR#AD18) U1.AE8(DVDD_DDR#AE8) U1.AE14(DVDD_DDR#AE14) U1.U8(DVDD_DDR#U8) U1.U10(DVDD_DDR#U10) U1.U12(DVDD_DDR#U12) U1.U14(DVDD_DDR#U14) U1.V7(DVDD_DDR#V7) U1.V11(DVDD_DDR#V11) U1.V13(DVDD_DDR#V13) U1.V15(DVDD_DDR#V15) U1.V17(DVDD_DDR#V17) U1.W16(DVDD_DDR#W16) U1.W18(DVDD_DDR#W18) U48.9(VIN-)
DVDD_DDRPLL: C189.1 C190.2 C192.2 C552.1 C557.2 FB20.2 U1.W8(DVDD_DDRDLL#W8) U1.W10(DVDD_DDRDLL#W10) U1.W14(DVDD_DDRDLL#W14)
GND_AUD_OSC: C220.1 C223.1 R720.1 U1.B17(VSS_OSC_AUDIO)
GND_CAN0: C347.2 C353.2 C753.2 P2.3 P2.5 P2.6 R582.2 U100.5(GND2) U105.3 U118.4(-VOUT_1) U118.5(-VOUT_2)
GND_CAN1: C345.2 C352.2 C755.2 P3.3 P3.5 P3.6 R583.2 U98.5(GND2) U104.3 U119.4(-VOUT_1) U119.5(-VOUT_2)
GND_DB9: FB34.1 P1.10 P1.11
GND_EARTH: C349.2 C351.2 J31.15(SH1) J31.16(SH2)
GND_HDMI: FB42.2 J36.20 J36.21 J36.22 J36.23
GND_MIPI: J19.61 J19.62 J19.63 J19.64 R349.2
GND_OSC: C72.2 C80.2 R652.1 U20.D18(GNDX2)
GND_PCIE: FL2.2 J5.SH1 J5.SH2
GND_R: R354.2 U41.7(A5) U41.10(A8)
GND_SDCD: FB43.2 J37.10 J37.11 J37.13 J37.14
GND_SYS: C232.2 C234.2 R724.1 U1.AD19(VSS_OSC_SYS) Y6.2(GND1) Y6.4(GND2)
GND_USB_XDS: FB1.2 J1.6(SH1) J1.7(SH2) U3.4(GND)
GNDSHLD0: P2.10 P2.11 R582.1
GNDSHLD1: P3.10 P3.11 R583.1
GNDUSB: FB33.1 J23.6(SH1) J23.7(SH2) J23.8(SH3) J23.9(SH4)
GNDUSB0: FB44.2 J35.5(SH1) J35.6(SH2)
GNDUSB1: FB46.2 J38.6(SH1) J38.7(SH2) J38.8(SH3) J38.9(SH4)
V0: C35.1 MOD1.1(V0)
V1: C36.1 MOD1.2(V1)
V2: C37.1 MOD1.3(V2)
V3: C38.1 MOD1.4(V3)
V4: C39.1 MOD1.5(V4)
V5_0HDMICONN: C707.1 J36.18 U108.13(5V_OUT)
VCC0V85: C205.1 C213.1 C267.1 FB22.1 FB30.1 U50.1(OUT)
VCC1V2: C315.1 C699.1 C735.1 FB35.2 FB39.2 U103.5(OUT)
VCC1V2_XDS: C24.1 C25.2 C29.2 L2.2 R83.2 R257.1 TP196.1(TP)
VCC1V2_XDS_CVDD: C42.1 C57.2 C59.2 C61.2 C88.2 C89.2 C388.1 C401.2 C406.2 C420.1 C423.2 R257.2 R296.1 U17.E5(RVDD#E5) U17.E15(CVDD#E15) U17.G7(CVDD#G7) U17.G8(CVDD#G8) U17.G13(CVDD#G13) U17.H6(CVDD#H6) U17.H7(CVDD#H7) U17.H10(CVDD#H10) U17.H11(CVDD#H11) U17.H12(CVDD#H12) U17.H13(CVDD#H13) U17.H14(RVDD#H14) U17.J6(CVDD#J6) U17.J12(CVDD#J12) U17.K6(CVDD#K6) U17.K12(CVDD#K12) U17.L12(CVDD#L12) U17.L14(RTC_CVDD) U17.M8(CVDD#M8) U17.M9(CVDD#M9) U17.M12(USB_CVDD) U17.N7(RVDD#N7) U17.N8(CVDD#N8)
VCC1V2_XDS_PLL: C90.2 C399.2 C421.2 C422.2 FL13.1 FL16.1 R296.2
VCC1V8_AUD: C326.1 C679.1 R536.2 R543.2 U96.36(DVDD.1)
VCC1V8_EMMC: C113.1 C133.1 C145.1 R258.2 R260.2 R268.2 R269.2 R271.2 R281.2 R286.2 R287.2 R292.2 R299.2 R304.2 R856.2 U29.C6(VCCQ1) U29.C7(NC22) U29.M4(VCCQ2) U29.N4(VCCQ3) U29.P3(VCCQ4) U29.P5(VCCQ5) U34.6(VCCB)
VCC1V8_WLAN: C15.1 C65.2 C68.2 C368.1 C762.1 FB8.2 FB9.2 J2.8 R52.1 R53.1 R54.1 R55.1 R56.1 R57.1 R58.1 R69.1 R138.2 R139.2 U125.16(VCCB) U126.16(VCCB) U128.16(VCCB)
VCC1V8_XDS: C16.1 C17.2 C28.2 D2.3(CATHODE) R293.1 R600.1 R608.2 TP197.1(TP) U6.12(VLDO1) U12.15(VCC)
VCC1V8_XDS_DVDD18: C44.2 C55.2 C85.2 C389.2 C395.2 C419.2 FB6.2 FL5.1(INPUT) R293.2 U17.F14(DVDD18#F14) U17.G6(DVDD18#G6) U17.G10(DVDD18#G10) U17.G11(DVDD18#G11) U17.G12(DVDD18#G12) U17.J13(DVDD18#J13) U17.K5(DVDD18#K5) U17.L6(DVDD18#L6) U17.P13(DVDD18#P13) U17.R13(DVDD18#R13)
VCC3V0_BMC_BKL: MOD1.A R100.2
VCC3V0_BMC_LCD: C387.2 R112.1 U10.5(VOUT)
VCC3V3_AUD: C294.2 C316.1 C339.1 C674.1 C692.2 C695.1 C696.1 C702.1 R503.1 R534.1 R755.1 R894.2 U75.4(VCC) U96.16(DRVDD.1) U96.17(DRVDD.2) U96.24(DRVDD.3) U96.25(AVDD_DAC) U96.44(IOVDD) U97.5(VCC)
VCC3V3_AUD_EXP: C169.1 C173.1 FB52.2 JP1.10 JP1.12
VCC3V3_BMC: C3.2 C4.1 C6.1 C31.1 C58.2 C69.1 C70.1 C92.1 C93.1 C102.1 C109.1 C122.1 C134.1 C143.1 C279.2 C287.2 C400.1 C403.1 C410.2 C426.2 C427.2 C435.1 C436.2 C461.1 C653.2 C654.2 C663.1 C681.1 C756.2 C816.1 C818.1 C819.1 J11.1 L1.2 R103.2 R106.1 R109.2 R132.1 R134.1 R135.1 R150.2 R168.2 R175.2 R179.2 R180.2 R183.2 R188.2 R190.2 R193.2 R196.2 R197.2 R199.2 R202.2 R204.2 R219.2 R224.2 R225.2 R227.2 R254.2 R255.2 R264.2 R266.2 R280.2 R282.2 R289.2 R290.2 R291.2 R310.2 R313.2 R316.2 R498.2 R501.2 R591.1 R601.2 R607.1 R633.2 R645.1 R646.1 R659.2 R660.2 R661.1 R662.2 R663.1 R664.2 R741.2 R747.2 R832.1 R837.2 R847.2 R859.2 R860.2 R861.2 R862.2 R863.1 R878.2 TP195.1(TP) U10.1(VIN) U13.15(VCC) U14.8(VCCB) U16.8(VCCB) U20.F3(VDDA) U20.F4(VREFA+) U20.G10(VDD#G10) U20.H9(VDD#H9) U20.J8(VDD#J8) U20.J9(VDD#J9) U20.J10(VDD#J10) U20.K7(VDD#K7) U20.K8(VDD#K8) U20.K11(VDD#K11) U20.K12(VDD#K12) U20.L10(VDD#L10) U20.L11(VDD#L11) U20.L12(VDD#L12) U20.M11(VDD#M11) U20.M12(VDD#M12) U20.N16(VDD#N16) U20.P10(VDD#P10) U20.P17(VDD#P17) U21.4(VDD) U24.1(VCCA) U30.1(VCCA) U31.1(VCCA) U33.1(VCCA) U35.1(VCCA) U66.7(VCCA) U67.31(VCCA#31) U67.42(VCCA#42) U76.7(VCCA) U101.5(VCC) U122.1(VCCA) U129.7(VCCA) U130.6(VCCB) U130.7(VCCA)
VCC3V3_CDCM: C276.1 C282.1 C467.2 C612.1 C639.1 C641.1 C642.1 C643.1 C646.1 C647.1 FL7.1 FL8.1 FL9.1 R475.1 R485.1 R731.1 R733.1 R895.2 U31.16(VCCB) U62.7(VDD_PRI_REF) U62.10(VDD_SEC_REF) U62.13(VDD_Y0_Y1#13) U62.18(VDD_Y0_Y1#18) U62.34(VDD_Y7) U62.48(DVDD)
VCC3V3_CP2105: C290.1 C291.1 C817.1 C821.1 R504.1 U74.5(VIO) U74.6(VDD) U129.6(VCCB) U146.6(VCCB)
VCC3V3_DC_CONN: C104.1 C744.1 C745.1 C746.1 C752.1 C754.1 FB5.1 FL19.1 L9.2 R824.1 R852.1 TP194.1(TP) U116.16(VO) U118.2(+VIN) U119.2(+VIN)
VCC3V3_DCIN: C1.1 C106.2 C107.1 C123.2 C124.2 C125.2 C126.2 C129.2 C131.2 C135.1 C136.2 C137.2 C138.2 C140.2 C147.1 C159.1 C162.2 C233.1 C236.1 C240.1 C255.1 C265.1 C266.1 C280.1 C284.1 C308.1 C311.1 C318.2 C320.2 C322.2 C323.1 C377.2 C396.2 C397.2 C441.1 C453.1 C460.2 C463.2 C464.2 C479.2 C486.2 C493.2 C498.1 C518.1 C519.1 C520.1 C532.1 C533.1 C545.1 C630.1 C632.1 C645.2 C648.2 C649.2 C650.2 C661.1 C671.1 C690.1 C703.2 C710.2 C711.2 C712.1 C713.2 C714.1 C717.2 C720.2 C723.2 C726.1 C761.2 C775.1 C776.1 C781.2 C782.2 C783.2 C784.2 C785.2 C786.1 C789.2 C790.2 C791.1 C792.1 C798.1 C800.2 C806.1 C807.1 C808.1 C809.1 C820.1 C822.1 FB7.1 FB11.1 FB14.1 FB26.2 FB31.2 FB32.1 FB48.1 FB49.1 FB52.1 FB53.1 J39.1 L10.2 R1.1 R3.1 R11.2 R12.1 R13.1 R14.1 R15.1 R16.1 R66.1 R192.1 R223.2 R236.2 R238.2 R239.2 R248.2 R249.2 R251.2 R253.2 R273.2 R274.2 R275.2 R276.2 R277.2 R278.2 R288.2 R300.2 R301.1 R321.1 R333.1 R339.2 R344.1 R348.1 R359.2 R368.1 R369.1 R371.1 R376.1 R377.1 R378.1 R379.1 R478.1 R491.1 R492.1 R497.1 R518.1 R526.1 R527.1 R550.1 R555.1 R557.1 R564.1 R588.1 R589.1 R665.2 R675.2 R698.1 R705.1 R706.1 R709.1 R726.1 R735.2 R749.2 R750.1 R784.2 R796.1 R835.2 R844.1 R845.1 R849.2 R858.1 R869.1 R870.1 R871.2 R874.1 R881.2 R882.2 R883.2 R884.2 R886.2 R893.1 R894.1 R895.1 R898.1 R910.1 R912.1 TP199.1(TP) U5.5(VCC) U14.1(VCCA) U16.1(VCCA) U23.5(VCC) U24.23(VCCB1) U24.24(VCCB2) U25.6(AVIN) U25.7(PVIN) U26.5(VCC) U30.16(VCCB) U32.D8(VCC5) U32.E1(VCC1_C) U32.F2(VCC1_B) U32.F3(VCC1_A) U32.G1(VCC2_B) U32.G2(VCC2_A) U32.N5(VCC6) U33.23(VCCB1) U33.24(VCCB2) U35.23(VCCB1) U35.24(VCCB2) U37.16(VCC) U38.8(VCC) U40.2(VCC) U41.23(VCCB1) U41.24(VCCB2) U42.6(VS+) U42.8(VBUS) U42.10(VIN+) U43.2(A0) U43.6(VS+) U44.6(VS+) U46.6(VS+) U47.5(VCC) U48.1(A1) U48.6(VS+) U51.21(VCC) U56.1(VD) U59.1(VCCA) U59.6(VCCB) U64.1(VCCA) U64.16(VCCB) U66.6(VCCB) U67.7(VCCB#7) U67.18(VCCB#18) U68.5(VCC) U76.6(VCCB) U86.5(VCC) U93.16(VCC) U95.1(VCCA) U95.8(VCCB) U98.1(VCC1) U100.1(VCC1) U106.5(VCC) U112.5(V+) U124.6(VCCB) U124.7(VCCA) U127.5(VCC) U131.5(VCC) U132.23(VCCB1) U132.24(VCCB2) U133.16(VCC) U134.16(VCC) U135.1(VCCA) U135.6(VCCB) U136.1(VCCA) U136.16(VCCB) U137.1(VCCA) U137.6(VCCB) U138.5(VCC) U139.5(VCC) U140.5(VCC) U141.16(VO) U146.7(VCCA) U147.6(VCCB) U147.7(VCCA)
VCC3V3_EMMC: C105.1 C144.1 C473.2 C483.2 R301.2 R694.1 U29.E6(VCC1) U29.F5(VCC2) U29.J10(VCC3) U29.K9(VCC4) U34.1(VCCA) U36.5(VCC)
VCC3V3_HDMI: C307.1 C324.1 C651.1 C652.1 C676.2 C706.2 C733.2 FB38.2 R555.2 R561.1 R742.1 R772.1 R813.1 U69.1(VCCA) U69.16(VCCB) U84.5(VCC) U91.5(VCC) U108.24(VCCA) U115.1(VCCA) U115.23(VCCB1) U115.24(VCCB2)
VCC3V3_LCD: C256.1 C257.1 C633.1 C638.2 FB32.2 J21.1 J22.4 R429.1 R455.1 R725.1 R729.1 U58.5(VCC)
VCC3V3_MIPI: C780.2 FB14.2 R317.2 R326.1 R328.1 R336.1 R343.1 R351.1 R355.1 R391.2 R865.2 R879.1 R904.1 U132.1(VCCA)
VCC3V3_MLB: C708.1 C709.1 FB48.2 J34.37 J34.38 J34.39 R854.2
VCC3V3_NAND: C667.1 C668.1 C669.1 C677.1 C678.1 R526.2 R760.1 R761.1 U87.12(VCC1) U87.34(VCC2) U87.37(VCC3) U87.39(VCC4)
VCC3V3_PCIE: C369.1 C370.1 C371.1 C372.1 FL19.2 J5.A9 J5.A10 J5.B8 R38.1 R43.1 R594.2 R855.2
VCC3V3_PCIE_AUX: C374.1 FB5.2 J5.B10 R802.1
VCC3V3_QSPI: C655.1 C656.1 C657.2 C659.2 R518.2 R743.1 R745.1 R746.1 U71.5(VCC) U72.2(VCC) U72.14(VIO/RFU)
VCC3V3_R: J19.1 R317.1
VCC3V3_SD: C356.1 C359.1 FB49.2 J37.4(VDD) R242.2 R577.2 R776.2 R777.2 R778.2 R779.2 R780.2 U107.1(VCC) U111.10(VCC)
VCC3V3_SER_EXP: C81.1 C82.1 FB53.2 J12.2 J12.4
VCC3V3_WLAN: C83.1 C84.1 C763.2 C815.1 FB7.2 R609.1 R830.2 R838.2 R842.2 R843.2 U125.1(VCCA) U126.1(VCCA) U128.1(VCCA) U144.5(VCC)
VCC3V3_XDS: C10.1 C12.2 C30.2 C46.2 C62.2 C165.2 C375.1 C378.1 C379.1 C380.1 C381.1 C382.1 C383.1 C392.1 J4.1 R31.2 R32.2 R33.2 R46.2 R72.2 R85.1 R101.1 R102.2 R105.1 R111.1 R113.2 R119.2 R123.2 R142.2 R143.2 R158.2 R169.2 R172.2 R178.2 R185.2 R187.2 R194.2 R270.1 R353.2 R603.2 R612.2 R613.2 R614.2 R615.2 R617.2 R621.1 R622.1 R623.1 R624.1 R636.2 R640.2 R641.2 R644.2 R649.2 R650.1 R905.1 TP198.1(TP) U2.5(SENSE) U6.15(VLDO2) U9.A7(VDDQ#A7) U9.A9(VDD#A9) U9.B3(VDDQ#B3) U9.C7(VDDQ#C7) U9.D3(VDDQ#D3) U9.E7(VDD#E7) U9.J9(VDD#J9) U11.8(VCC) U12.7(VCCIO1) U12.35(VAUX) U41.1(VCCA)
VCC3V3_XDS_DVDD33: C43.1 C45.2 C47.2 C67.2 C71.2 C86.2 C87.2 C390.2 C393.2 C409.2 C411.2 C418.2 C424.2 FL3.1(INPUT) R270.2 U17.E14(DVDD3318_B#E14) U17.F5(DVDD3318_A#F5) U17.F6(DVDD3318_B#F6) U17.F7(DVDD3318_B#F7) U17.F8(DVDD3318_B#F8) U17.F10(DVDD3318_B#F10) U17.F11(DVDD3318_B#F11) U17.F12(DVDD3318_B#F12) U17.F13(DVDD3318_B#F13) U17.F15(DVDD3318_A#F15) U17.G5(DVDD3318_A#G5) U17.G9(DVDD3318_B#G9) U17.G14(DVDD3318_A#G14) U17.G15(DVDD3318_A#G15) U17.H5(DVDD3318_A#H5) U17.J5(DVDD3318_C#J5) U17.J14(DVDD3318_B#J14) U17.K13(DVDD3318_C#K13) U17.K15(DVDD3318_B#K15) U17.L4(DVDD3318_C#L4) U17.L13(DVDD3318_C#L13) U17.M13(DVDD3318_C#M13) U17.N13(DVDD3318_C#N13) U17.P5(DVDD3318_C#P5) U17.P6(DVDD3318_C#P6) U17.P12(DVDD3318_C#P12) U17.R4(DVDD3318_C#R4)
VCC5V0_DCDC: C11.1 C13.1 C19.1 C26.1 C48.1 C49.1 C50.1 C108.1 C112.2 C114.2 C150.2 C154.2 C155.2 C156.1 C206.1 C468.1 C471.2 C484.2 C485.1 C622.1 C634.1 J17.3 L3.2 R67.2 R155.1 R334.1 R457.1 R568.1 R592.1 R611.2 R692.1 TP42.1(TP) U6.6(VINDCDC) U6.13(VINLDO1) U6.16(VINLDO2) U8.1(IN1) U8.2(IN2) U32.A5(V5IN) U32.B6(VCC7) U32.L1(VCC4) U32.L7(VCCIO_B) U32.L8(VCCIO_A) U32.N3(VCC3) U50.4(IN) U54.2(IN1) U54.3(IN2) U57.2(IN1) U57.3(IN2)
VCC5V0_HDMI: C697.1 C704.2 R568.2 U103.1(IN) U108.11(VCC5V)
VCC5V0_LCD: C222.1 R456.1 R457.2 U53.2(VIN)
VCC5V0_USB0_PM: FB45.1 U1.B19(USB0_VBUS) U54.6(OUT1) U54.7(OUT2) U54.8(OUT3)
VCC5V0_USB1_PM: FB47.1 U1.A21(USB1_VBUS) U57.6(OUT1) U57.7(OUT2) U57.8(OUT3)
VCC5V_UART2: J49.3 R914.1
VCC5V_VUSB_CP2105: C286.1 C305.1 C338.1 J23.1(VCC) U73.6(VBUS) U74.7(REGIN) U74.8(VBUS)
VCC12V0_AUD_EXP: C166.1 C167.1 FL6.2 JP1.2 JP1.4 JP1.6
VCC12V0_DC_IN: C2.1 C18.2 C20.1 C22.1 C23.1 C74.1 C75.1 C76.1 C95.1 C96.1 C97.1 C98.1 C99.2 C414.1 C737.1 C738.1 C739.1 C740.1 C801.1 C802.1 C803.1 C804.1 FB51.1 FL1.1 FL6.1 FL11.1 J50.1 Q20.3(S) R30.1 R610.1 R826.2 R892.1 TP63.1(TP) TP64.1(TP) U7.7(VIN) U18.4(PVIN1) U18.5(PVIN2) U18.6(VIN) U22.1(VIN1) U116.13(VIN1) U116.14(VIN2) U116.15(VIN3) U141.13(VIN1) U141.14(VIN2) U141.15(VIN3)
VCC12V0_MLB: C357.1 C358.1 C360.1 FL11.2 J34.40
VCC12V0_PCIE: C5.1 C365.1 C366.1 FL1.2 J5.A2 J5.A3 J5.B1 J5.B2 J5.B3
VCC12V0_SER_EXP: C749.1 C750.1 FB51.2 J12.1 J12.3
VCC_BMC_LCD: C33.2 C34.2 MOD1.12(VDD) R100.1 R106.2 R112.2
VCC_DDR_VREF: C100.1 C103.2 C440.2 C455.2 C487.2 C500.2 C510.2 C521.2 C540.2 C554.2 C561.2 C578.2 C610.2 R403.2 U25.4(VREF) U27.E1(VREFDQ) U27.J8(VREFCA) U39.E1(VREFDQ) U39.J8(VREFCA) U45.E1(VREFDQ) U45.J8(VREFCA) U49.E1(VREFDQ) U49.J8(VREFCA) U52.E1(VREFDQ) U52.J8(VREFCA)
VCC_VBUS_XDS: C7.1 C9.1 C364.1 C367.1 FB3.2 R47.1 R64.2 R76.1 U2.6(VDD) U4.5(VCC)
VDD2_PLL1: C269.1 C635.1 FB31.1 U62.37(VDD_PLL1)
VDD2_PLL2: C262.1 C626.1 FB26.1 U62.38(VDD_PLL2) U62.39(VDD_VCO)
VDD18_1V8: C175.1 C184.1 C527.1 FB19.2 U1.H5(DVDD18#H5)
VDDAHV: C201.1 C204.1 C572.1 FB21.2 U1.K7(VDDAHV)
VDDI: C146.1 C492.1 U29.C1(NC19) U29.C2(VDDI)
VDDR_VTT: C117.1 C118.2 C429.1 C430.1 C431.1 C432.1 C433.1 C434.1 C437.1 C438.1 C447.1 C454.1 C458.1 C470.1 C480.1 C481.1 C482.1 R206.2 R207.2 R208.2 R209.2 R210.2 R211.2 R212.2 R213.2 R214.2 R215.2 R222.1 R230.2 R233.2 R237.2 R241.2 R247.2 R256.2 R261.2 R279.2 R285.2 R295.2 R305.2 R306.2 R307.2 R308.2 R309.2 U25.8(VTT)
VINPUT: C824.1 C825.1 D3.1(CATHODE) J50.2 Q20.4(D) R917.1 R918.1 R919.1 R922.1 R923.1 R925.2 U149.2(VIN)
VSS_RTC: C52.2 C53.2 R630.1 U17.H18(VSS_RTC)
1P8V_EN: R338.2 R345.2 U50.3(EN)
24MHZ_LVCMOS_USB0_CLK: R489.1 U62.29(Y5_P)
24MHZ_LVCMOS_USB1_CLK: R488.1 U62.28(Y5_N)
24MHZ_LVDS_N: R22.1 U62.25(Y4_N)
24MHZ_LVDS_P: R21.1 U62.26(Y4_P)
100MHZ_HCSL_N: R891.1 U62.36(Y7_N)
100MHZ_HCSL_P: R890.1 U62.35(Y7_P)
100MHZ_LVDS_N: R18.1 U62.21(Y2_N)
100MHZ_LVDS_P: R17.1 U62.20(Y2_P)
250MHZ_LVDS_CPTS_REF_CLKN: R24.2 U1.L21(CPTS_REFCLK_N)
250MHZ_LVDS_CPTS_REF_CLKP: R23.2 U1.K21(CPTS_REFCLK_P)
250MHZ_LVDS_N: R24.1 U62.33(Y6_N)
250MHZ_LVDS_P: R23.1 U62.32(Y6_P)
ATTENTIONZ: D10.1(K) R289.1 SW7.1(A1) SW7.2(A2) U20.D6(PP0/C2+/EN0INTRN/SSI3XDAT2/T6CC)
AUD_AGND: C339.2 C687.1 C691.1 C695.2 C696.2 C702.2 FB41.1 J32.1(S) J33.1(S) U96.15(AVSS_ADC) U96.20(DRVSS.1) U96.21(DRVSS.2) U96.26(AVSS_DAC) U96.49(TPAD)
AUD_BUFF_CLK_DIR: R492.2 R502.2 U136.2(1DIR)
AUD_BUFF_DAT_DIR: R910.2 R911.2 U136.3(2DIR)
AUD_BUFF_EN: R796.2 SW15.2 U136.14(2\O\E\) U136.15(1\O\E\)
AUD_MCLK_R: R537.2 U96.37(MCLK)
AUDIO_RSTN: R275.1 U35.19(B3) U97.1(A)
AUDIO_RSTN_AND: U96.33(R\E\S\E\T\) U97.4(Y)
BKLT_L: L8.1 U53.1(L)
BKLT_SW: L8.2 U53.10(SW)
BMC_AUDIO_RSTN: R193.1 U20.K19(PM1/EPI0S14/T2CCP1) U35.5(A3)
BMC_BLUE_LED: R602.2 U20.K3(PC7/C0-/EPI0S4/U5TX)
BMC_BOOTMODE0: U20.D12(PS0/LCDDATA20/M0FAULT0/T2CCP0) U67.43(1A4)
BMC_BOOTMODE1: U20.R13(PS7/EN0RXDV/LCDDATA09/T5CCP1) U67.40(1A6)
BMC_BOOTMODE2: U20.D13(PS1/LCDDATA21/M0FAULT1/T2CCP1) U67.44(1A3)
BMC_BOOTMODE3: U20.A14(PS3/LCDDATA23/M0FAULT3/T3CCP1) U67.47(1A1)
BMC_BOOTMODE4: U20.T13(PS5/EN0TXD1/LCDDATA07/PHB0/T4CC) U67.37(1A8)
BMC_BOOTMODE5: U20.B14(PS2/LCDDATA22/M0FAULT2/T3CCP0/U) U67.46(1A2)
BMC_BOOTMODE6: U20.U10(PS6/EN0RXER/IDX0/LCDDATA08/T5CC) U67.38(1A7)
BMC_BOOTMODE7: U20.P2(PR5/I2C3SDA/LCDDATA01/M0PWM5/T0) U67.41(1A5)
BMC_BOOTMODE8: U20.V9(PS4/EN0TXD0/LCDDATA06/PHA0/T4CC) U67.33(2A3)
BMC_BOOTMODE9: U20.N4(PR1/I2C1SDA/LCDFP/M0PWM1/U4RX) U67.30(2A5)
BMC_BOOTMODE10: U20.W9(PR6/I2C4SCL/LCDDATA04/M0PWM6/T1) U67.35(2A2)
BMC_BOOTMODE11: U20.R10(PR7/EN0TXEN/I2C4SDA/LCDDATA05/M) U67.36(2A1)
BMC_BOOTMODE12: U20.N5(PR0/I2C1SCL/LCDCP/M0PWM0/U4TX) U67.29(2A6)
BMC_BOOTMODE13: U20.V8(PR3/I2C2SDA/LCDDATA03/M0PWM3) U67.32(2A4)
BMC_BOOTMODE14: U20.N2(PR2/I2C2SCL/LCDLP/M0PWM2) U67.27(2A7)
BMC_BOOTMODE15: U20.P3(PR4/I2C3SCL/LCDDATA00) U67.26(2A8)
BMC_BOOTSELECT: J10.1 R225.1 U20.V2(PH7/U5TX/U7TX)
BMC_CDCM_RST: U20.E7(PJ1/U3TX) U33.4(A2)
BMC_CLK_PDN: U20.T8(PF6/LCDMCLK) U31.4(1A1)
BMC_CLK_REF_SEL: U20.F16(PJ3/LCDDATA15/U2CTS) U33.8(A6)
BMC_CLK_SYNC: U20.U8(PF7/LCDDATA02) U31.5(1A2)
BMC_CP2105_RXD: U74.21(TXD_SCI) U129.4(B2)
BMC_CP2105_TXD: U74.20(RXD_SCI) U129.5(B1)
BMC_EEPROM_WP: U20.E17(PJ5/LCDDATA17/U3CTS) U33.6(A4)
BMC_EMMC_RSTN: R204.1 U20.N18(PM7/EN0COL/T5CCP1/TMPR0/U0RI) U35.8(A6)
BMC_ETH_RSTN: R199.1 U20.K18(PM0/EPI0S15/T2CCP0) U35.6(A4)
BMC_FLASH_RESET#: U20.F18(PJ4/LCDDATA16/U3RTS) U33.5(A3)
BMC_FLASH_WPN: U20.H17(PJ2/LCDDATA14/U2RTS) U33.7(A5)
BMC_GPIO0: JP1.89 R164.2
BMC_GPIO1: JP1.88 R162.2
BMC_GPIO3: JP1.87 R161.2
BMC_GPIO4: JP1.90 R163.2
BMC_GPIO5: JP1.93 R160.2
BMC_GPIO6: JP1.94 R221.2
BMC_GREEN_LED: R41.2 R601.1 U20.L2(PC6/C0+/EPI0S5/U5RX)
BMC_HDMI_RSTN: R662.1 U20.L18(PM2/EPI0S13/T3CCP0) U35.4(A2)
BMC_HIBN: TP98.1(TP) U20.M17(H\I\B\)
BMC_I2C0_SCL: R118.1 R844.2 U14.2(SCLA)
BMC_I2C0_SDA: R117.1 R845.2 U14.3(SDAA)
BMC_I2C1_SCL: R200.1 R661.2 U16.7(SCLB)
BMC_I2C1_SDA: R203.1 R663.2 U16.6(SDAB)
BMC_INT1: U1.D14(PR1_PRU1_GPO4/PR1_PRU1_GPI4/GPI) U24.15(B7)
BMC_ISOL_EN1: R228.2 R859.1 U20.K15(PG5/EN0TXD1/I2C3SDA/OWALT/SSI2X) U24.22(O\E\)
BMC_ISOL_EN2: R272.2 R860.1 U20.K17(PG4/EN0TXD0/I2C3SCL/OWIRE/SSI2X) U35.22(O\E\)
BMC_ISOL_EN3: R686.2 R862.1 U20.V12(PG6/EN0RXER/I2C4SCL/OWIRE/SSI2F) U30.14(2\O\E\) U30.15(1\O\E\)
BMC_ISOL_EN4: R263.2 R861.1 U20.U14(PG7/EN0RXDV/I2C4SDA/OWIRE/SSI2C) U33.22(O\E\)
BMC_ISOL_EN5: R283.2 R863.2 U20.R7(PA7/EPI0S9/I2C6SDA/SSI0XDAT3/T3) U31.14(2\O\E\)
BMC_JTAG_TCK: R639.1 U20.B15(PC0/SWCLK/TCK)
BMC_JTAG_TDI: J7.3 U20.D14(PC2/TDI)
BMC_JTAG_TDO: J7.7 R878.1 U20.C14(PC3/SWO/TDO)
BMC_JTAG_TMS: J7.1 R188.1 U20.C15(PC1/SWDIO/TMS)
BMC_JTAG_TRSTN: J7.2 R786.1 TP176.1(TP)
BMC_LCD_A0: MOD1.15(A0) U20.F1(PB7/I2C6SDA/T6CCP1)
BMC_LCD_RSTN: MOD1.16(R\S\T\) U20.F2(PB6/I2C6SCL/T6CCP0)
BMC_LRESETN: U20.C18(PL6/T1CCP0/USB0DP) U24.3(A1)
BMC_LRESETNMIENN: U20.B18(PL7/T1CCP1/USB0DM) U24.4(A2)
BMC_MLB_RSTN: R659.1 U20.G15(PM5/T4CCP1/TMPR2/U0DCD) U35.10(A8)
BMC_NMIN: R180.1 R655.2 U20.G16(PL0/EPI0S16/I2C2SDA/M0FAULT3/US) U24.5(A3)
BMC_OSC0: C80.1 R171.2 U20.E19(OSC0) Y3.1(HOT1)
BMC_OSC1: C72.1 R171.1 U20.D19(OSC1) Y3.3(HOT2)
BMC_PCIE_RSTN: R202.1 U20.N19(PM6/EN0CRS/T5CCP0/TMPR1/U0DSR) U35.9(A7)
BMC_PORN: J16.2 U20.G19(PL5/EPI0S33/T0CCP1/USB0D5) U24.8(A6)
BMC_QSPI_RSTN: R660.1 U20.L19(PM3/EPI0S12/T3CCP1) U35.3(A1)
BMC_RESET_FULLN: U20.H19(PL1/EPI0S17/I2C2SCL/PHA0/USB0D1) U24.6(A4)
BMC_RESETZ: C799.1 D9.1(K) R254.1 R885.2 U20.P18(R\S\T\)
BMC_RSV6_TOGGLE: U20.C8(PJ0/EN0PPS/U3RX) U33.3(A1)
BMC_SOC_RESETN: U20.H18(PL4/EPI0S26/T0CCP0/USB0D4) U24.7(A5)
BMC_SPI0_CLK: R220.2 U30.4(1A1)
BMC_SPI0_CS0N: U20.U5(PA3/I2C8SDA/SSI0FSS/T1CCP1/U4TX) U31.6(2A1)
BMC_SPI0_MISO: R232.2 R667.2 U30.6(2A1)
BMC_SPI0_MOSI: R231.2 R666.2 U30.5(1A2)
BMC_SPI1_CLK: MOD1.14(SCL) U20.B6(PB5/AIN11/I2C5SDA/SSI1CLK/U0RTS)
BMC_SPI1_CSN: MOD1.17(C\S\1\) U20.C6(PB4/AIN10/I2C5SCL/SSI1FSS/U0CTS)
BMC_SPI1_MOSI: MOD1.13(SI) R170.1 R177.1
BMC_SYSCLKSEL: J15.2 U20.K5(PJ7/U4CTS) U33.10(A8)
BMC_TSC_WAKEN: R664.1 U20.M18(PM4/EN0RREF_CLK/T4CCP0/TMPR3/U0) U35.7(A5)
BMC_TXVR_RXD: U13.9(ROUT) U130.4(B2)
BMC_TXVR_TXD: U13.11(DIN) U130.5(B1)
BMC_UART0_CP2105_EN: U101.4(Y) U129.2(O\E\)
BMC_UART0_DETECT: J6.1 R132.2 U20.T2(PH5/EN0PPS/U0RI) U101.2(A) U130.2(O\E\)
BMC_UART0_EN: R103.1 R625.2 U13.1(E\N\)
BMC_UART0_RX: U20.V3(PA0/CAN0RX/I2C9SCL/T0CCP0/U0RX) U129.9(A2) U130.9(A2)
BMC_UART0_TX: U20.W3(PA1/CAN0TX/I2C9SDA/T0CCP1/U0TX) U129.8(A1) U130.8(A1)
BMC_UART1_RX: R166.2 U76.9(A2)
BMC_UART1_TX: R174.2 U76.8(A1)
BMC_UART_SEL: R914.2 R915.2 U20.U2(PH6/U5RX/U7RX) U68.2(A) U76.2(O\E\)
BMC_WAKEN: J9.2 U20.U18(W\A\K\E\)
BMC_XOSC0: R205.1 U21.3(OUT)
BMC_XOSC0_R: R205.2 U20.T18(XOSC0)
BOOTMODEON: R501.1 R744.2 U20.G18(PL2/C0O/EPI0S18/PHB0/USB0D2) U66.2(O\E\) U67.25(2O\E\) U67.48(1O\E\)
BT_EN: U51.7(P06) U128.6(2A1)
BUF_CP2105_RXD: U74.13(TXD_ECI) U146.4(B2)
BUF_CP2105_TXD: U74.12(RXD_ECI) U146.5(B1)
BUF_ETH_RSTN: C336.1 D4.2(A) R529.1 R566.2 U88.4(Y) U92.42(RESET_N)
BUF_I2C1_SCL: JP1.97 R550.2 R579.2 U95.2(SCLA)
BUF_I2C1_SDA: JP1.98 R557.2 R578.2 U95.3(SDAA)
BUF_MCASP0AHCLKX: JP1.70 R876.1 U139.4(Y)
BUF_MCASP2ACLKX: TP193.1(TP) U69.5(1A2) U96.38(BCLK) U136.13(1B1)
BUF_MCASP2AXR2: TP206.1(TP) U69.7(2A2) U96.40(DIN) U136.11(2B1)
BUF_MCASP2AXR3: R762.2 TP207.1(TP) U137.3(A)
BUF_MCASP2FSX: TP205.1(TP) U69.6(2A1) U96.39(WCLK) U136.12(1B2)
BUF_MIPI_TCK: R866.1 U134.3(IA1)
BUF_MIPI_TDI: U132.20(B2) U134.6(IB1)
BUF_MIPI_TMS: U132.18(B4) U134.13(ID1)
BUF_MIPI_TRST#: U132.19(B3) U134.10(IC1)
BUF_MMC1_CLK: R713.1 U142.20(B1)
BUF_MMC1_CMD: R714.1 U142.18(B2)
BUF_MMC1_DAT0: RA15.8 U142.17(B3)
BUF_MMC1_DAT1: RA15.7 U142.16(B4)
BUF_MMC1_DAT2: RA15.6 U142.15(B5)
BUF_MMC1_DAT3: RA15.5 U142.14(B6)
BUF_SOC_TDO: U59.4(B) U133.4(YA)
BUF_TXVR_RXD: R547.2 U147.4(B2)
BUF_TXVR_TXD: R542.1 U147.5(B1)
BUF_XDS_TCK: R323.1 U134.2(IA0)
BUF_XDS_TDI: U41.20(B2) U134.5(IB0)
BUF_XDS_TMS: U41.18(B4) U134.14(ID0)
BUF_XDS_TRST#: U41.19(B3) U134.11(IC0)
BUFF_DSS_DE: R512.1 U82.F6(3A4) U82.M6(6A4)
BUFF_DSSDATA0: RA10.8 U81.A5(1A1) U81.J5(5A1)
BUFF_DSSDATA1: RA10.7 U81.A6(1A2) U81.J6(5A2)
BUFF_DSSDATA2: RA10.6 U81.B5(1A3) U81.K5(5A3)
BUFF_DSSDATA3: RA10.5 U81.B6(1A4) U81.K6(5A4)
BUFF_DSSDATA4: RA7.8 U81.C5(2A1) U81.L5(6A1)
BUFF_DSSDATA5: RA7.7 U81.C6(2A2) U81.L6(6A2)
BUFF_DSSDATA6: RA7.6 U81.D5(2A3) U81.M5(6A3)
BUFF_DSSDATA7: RA7.5 U81.D6(2A4) U81.M6(6A4)
BUFF_DSSDATA8: RA9.16 U81.E5(3A1) U81.N5(7A1)
BUFF_DSSDATA9: RA9.15 U81.E6(3A2) U81.N6(7A2)
BUFF_DSSDATA10: RA9.12 U81.F5(3A3) U81.P5(7A3)
BUFF_DSSDATA11: RA9.14 U81.F6(3A4) U81.P6(7A4)
BUFF_DSSDATA12: RA9.9 U81.G5(4A1) U81.R5(8A1)
BUFF_DSSDATA13: RA9.10 U81.G6(4A2) U81.R6(8A2)
BUFF_DSSDATA14: RA9.13 U81.H6(4A3) U81.T6(8A3)
BUFF_DSSDATA15: RA9.11 U81.H5(4A4) U81.T5(8A4)
BUFF_DSSDATA16: RA8.13 U82.A5(1A1) U82.G5(4A1)
BUFF_DSSDATA17: RA8.15 U82.A6(1A2) U82.G6(4A2)
BUFF_DSSDATA18: RA8.10 U82.B5(1A3) U82.H6(4A3)
BUFF_DSSDATA19: RA8.16 U82.B6(1A4) U82.H5(4A4)
BUFF_DSSDATA20: RA8.9 U82.C5(2A1) U82.J5(5A1)
BUFF_DSSDATA21: RA8.11 U82.C6(2A2) U82.J6(5A2)
BUFF_DSSDATA22: RA8.14 U82.D5(2A3) U82.K5(5A3)
BUFF_DSSDATA23: RA8.12 U82.D6(2A4) U82.K6(5A4)
BUFF_DSSHSYNC: R514.1 U82.E6(3A2) U82.L6(6A2)
BUFF_DSSPCLK: R513.1 U82.E5(3A1) U82.L5(6A1)
BUFF_DSSVSYNC: R511.1 U82.F5(3A3) U82.M5(6A3)
CDCM_1V8: C777.1 C778.1 R857.2 R896.2 U62.19(VDD_Y2_Y3#19) U62.24(VDD_Y2_Y3#24) U62.27(VDD_Y4) U62.30(VDD_Y5) U62.31(VDD_Y6)
CDCM_PDN#: R474.1 U31.13(1B1) U62.43(PDN)
CDCM_RST: C637.1 U33.20(B2) U62.44(RESETN/PWR)
CDCM_SPI_CLK: U30.13(1B1) U62.5(SCL/PIN4)
CDCM_SPI_CS0: U31.11(2B1) U62.4(SCS/AD1/PIN3)
CDCM_SPI_MISO: U30.11(2B1) U62.3(SDO/AD0/PIN2)
CDCM_SPI_MOSI: U30.12(1B2) U62.2(SDI/SDA/PIN1)
CDCM_SYNC#: R475.2 U31.12(1B2) U62.42(SYNCN)
CLK2_SI_MODE0: R483.1 R733.2 U62.1(SI_MODE0)
CLK2_SI_MODE1: R479.1 R731.2 U62.47(SI_MODE1)
CLK32KOUT: R674.1 TP101.1(TP) U32.F4(CLK32KOUT)
CLK_REF_SEL: R485.2 R738.1 U33.16(B6) U62.6(REF_SEL)
COM8_AUD_CLK: U64.4(1A1) U125.4(1A1)
COM8_AUD_FSYNC: U64.5(1A2) U125.5(1A2)
COM8_BUFF_CLK_DIR: R490.2 R491.2 U64.2(1DIR)
COM8_BUFF_DAT_DIR: R912.2 R913.2 U64.3(2DIR)
COM8_BUFF_EN: R750.2 SW11.2 U64.14(2\O\E\) U64.15(1\O\E\)
COM8_MCASP2AXR1: U128.4(1A1) U135.4(B)
COM8_MCASP2AXR4: U64.6(2A1) U125.6(2A1)
COM8_MMC1_CLK: J2.20 R58.2 U142.1(A1)
COM8_MMC1_CMD: J2.24 R57.2 U142.3(A2)
COM8_MMC1_DAT0: J2.26 R56.2 U142.4(A3)
COM8_MMC1_DAT1: J2.28 R55.2 U142.5(A4)
COM8_MMC1_DAT2: J2.30 R54.2 U142.6(A5)
COM8_MMC1_DAT3: J2.32 R53.2 U142.7(A6)
COM_AUD_CLK: J2.52 R51.1
COM_AUD_FSYNC: J2.54 R50.1
COM_AUD_IN: J2.56 R49.1
COM_AUD_OUT: J2.58 R48.1
COM_BTRST: J2.89 R590.2
COM_BTUARTCTS: J2.70 R61.1
COM_BTUARTDEBUG: J2.76 TP31.1(TP)
COM_BTUARTRTS: J2.72 R60.1
COM_BTUARTRX: J2.68 R62.1
COM_BTUARTTX: J2.66 R63.1
COM_GPIO9: J2.78 TP30.1(TP)
COM_GPIO10: J2.100 TP33.1(TP)
COM_GPIO11: J2.96 TP35.1(TP)
COM_GPIO12: J2.98 TP34.1(TP)
COM_SLOW_CLK: J2.1 R593.2
COM_WL_IRQ: J2.34 R52.2 R605.1
COM_WL_RS232_RX: J2.13 TP25.1(TP)
COM_WL_RS232_TX: J2.11 TP26.1(TP)
COM_WL_RST: J2.4 R59.1
COM_WL_UART_DBG: J2.15 TP23.1(TP)
CP2105_DM: J23.2(D-) U73.2(D-) U74.4(D-)
CP2105_DP: J23.3(D+) U73.1(D+) U74.3(D+)
CPLD_A0: RA14.6 U9.H7(A0) U12.2(I/O_2)
CPLD_A1: RA14.8 U9.H8(A1) U12.3(I/O_3)
CPLD_A2: RA14.5 U9.J8(A2) U12.5(I/O_4)
CPLD_A3: RA14.7 U9.J7(A3) U12.6(I/O_5)
CPLD_BIO_0: R91.1 U12.42(I/O_31)
CPLD_BIO_1: RA13.7 U12.43(I/O_32)
CPLD_BIO_2: RA13.6 U12.44(I/O_33)
CPLD_BIO_3: R126.1 RA13.5 U12.1(I/O_1)
CPLD_BIO_4: R148.1 RA13.8 U12.41(I/O_30)
CPLD_CSN: R93.1 R614.1 U12.8(I/O_6)
CPLD_D0: RA2.1 U9.A8(DQ0) U12.39(I/O_28)
CPLD_D1: RA2.3 U9.B9(DQ1) U12.40(I/O_29)
CPLD_I/O_10: R78.1 R612.1 U12.16(I/O_10)
CPLD_RDN: R615.1 R616.1 U12.12(I/O_7)
CPLD_RESETN: R79.1 U12.13(I/O_8) U17.B10(EMA_A[21]/MMCSD0_DAT[0]/GP4[5])
CPLD_RXD1: R148.2 U17.E18(S\P\I\1\_\S\C\S\[3]\/UART1_RXD/)
CPLD_TCK: J4.2 R45.1 R189.1 U12.11(TCK)
CPLD_TDI: J4.4 U12.9(TDI) U17.U1(GP7[14])
CPLD_TDO: J4.5 U12.24(TDO) U17.U2(GP7[15])
CPLD_TMS: J4.3 R46.1 U12.10(TMS) U17.V3(GP7[13])
CPLD_TXD1: R126.2 U17.F19(S\P\I\1\_\S\C\S\[2]\/UART1_TXD/)
CPLD_WEN: R617.1 R618.1 U9.F9(WE#) U12.14(I/O_9)
CS2_AD0: R478.2 R730.1 U56.8(AD0/C\S\)
CS2000_AUX_OUT: U1.F14(PR1_PRU1_GPO6/PR1_PRU1_GPI6/GPI) U56.4(AUX_OUT)
CS2000_CLKIN: R816.1 R817.1 U56.5(CLK_IN)
CVDD: C181.1 C183.1 C188.1 C191.1 C193.1 C194.1 C195.1 C196.1 C200.1 C214.1 C215.1 C228.2 C237.1 C246.2 C248.2 C263.1 C264.1 C451.2 C535.2 C537.2 C549.1 C551.1 C553.1 C556.1 C558.1 C560.1 C562.1 C567.1 C586.1 C587.2 C590.1 C591.2 C593.2 C599.2 C611.2 C618.1 C620.2 C627.1 C628.1 C716.2 C794.1 C795.1 C796.1 C797.1 J40.2 R357.1 U1.J10(CVDD#J10) U1.J14(CVDD#J14) U1.J16(CVDD#J16) U1.K9(CVDD#K9) U1.K11(CVDD#K11) U1.K13(CVDD#K13) U1.K15(CVDD#K15) U1.K17(CVDD#K17) U1.L10(CVDD#L10) U1.L12(CVDD#L12) U1.L14(CVDD#L14) U1.L16(CVDD#L16) U1.L18(CVDD#L18) U1.M9(CVDD#M9) U1.M11(CVDD#M11) U1.M13(CVDD#M13) U1.M15(CVDD#M15) U1.M17(CVDD#M17) U1.N10(CVDD#N10) U1.N12(CVDD#N12) U1.N14(CVDD#N14) U1.N16(CVDD#N16) U1.P9(CVDD#P9) U1.P11(CVDD#P11) U1.P13(CVDD#P13) U1.P15(CVDD#P15) U1.P17(CVDD#P17) U1.R8(CVDD#R8) U1.R10(CVDD#R10) U1.R12(CVDD#R12) U1.R14(CVDD#R14) U1.R16(CVDD#R16) U1.R18(CVDD#R18) U1.T9(CVDD#T9) U1.T11(CVDD#T11) U1.T15(CVDD#T15) U1.T17(CVDD#T17) U1.U16(CVDD#U16) U32.B4(VOUT) U43.9(VIN-)
CVDD1: C172.1 C176.1 C182.1 C216.1 C247.1 C536.2 C619.2 C719.2 J41.2 R360.1 U1.J12(CVDD1#J12) U1.M5(CVDD1#M5) U1.N8(CVDD1#N8) U1.N18(CVDD1#N18) U1.T13(CVDD1#T13) U44.9(VIN-)
CVDD_EN: R340.2 R346.2
DAC_VOUT: C670.1 R486.2 U79.3(VFB) U79.4(VOUT)
DAT0: R688.1 U29.A3(DAT0)
DAT1: R682.1 U29.A4(DAT1)
DAT2: R679.1 U29.A5(DAT2)
DAT3: R695.1 U29.B1(NC10) U29.B2(DAT3)
DAT4: R691.1 U29.A2(NC2) U29.B3(DAT4)
DAT5: R685.1 U29.B4(DAT5) U29.C3(NC20) U29.D1(NC30) U29.D2(NC31)
DAT6: R680.1 U29.B5(DAT6) U29.C5(NC21)
DAT7: R673.1 U29.A9(NC4) U29.B6(DAT7) U29.B7(NC11) U29.B8(NC12) U29.B9(NC13)
DBG_EMU0: R240.1 R636.1 U17.J16(EMU0)
DBG_EMU1: R243.1 R641.1 U17.K16(EMU1)
DBG_RTCK: J8.9 R141.1
DBG_SRST: J8.15 R156.1
DBG_TCK: J8.11 R149.2 U17.J15(TCK)
DBG_TDI: J8.3 U17.M16(TDI)
DBG_TDO: J8.7 U17.J18(TDO)
DBG_TMS: J8.1 U17.L16(TMS)
DBG_TRSTN: J8.2 R782.1 U17.L17(T\R\S\T\)
DC_BRD_DET: JP1.92 R192.2 R195.2 R806.2 R875.2 U69.14(2\O\E\) U69.15(1\O\E\)
DC_BRD_DET_INV: U84.4(Y) U115.22(O\E\)
DDR_A0: R279.1 U1.AC15(DDR3_A00) U27.K3(A0) U39.K3(A0) U45.K3(A0) U49.K3(A0) U52.K3(A0)
DDR_A1: R295.1 U1.Y15(DDR3_A01) U27.L7(A1) U39.L7(A1) U45.L7(A1) U49.L7(A1) U52.L7(A1)
DDR_A2: R285.1 U1.AC16(DDR3_A02) U27.L3(A2) U39.L3(A2) U45.L3(A2) U49.L3(A2) U52.L3(A2)
DDR_A3: R256.1 U1.AA15(DDR3_A03) U27.K2(A3) U39.K2(A3) U45.K2(A3) U49.K2(A3) U52.K2(A3)
DDR_A4: R261.1 U1.AB16(DDR3_A04) U27.L8(A4) U39.L8(A4) U45.L8(A4) U49.L8(A4) U52.L8(A4)
DDR_A5: R230.1 U1.AE17(DDR3_A05) U27.L2(A5) U39.L2(A5) U45.L2(A5) U49.L2(A5) U52.L2(A5)
DDR_A6: R233.1 U1.AC14(DDR3_A06) U27.M8(A6) U39.M8(A6) U45.M8(A6) U49.M8(A6) U52.M8(A6)
DDR_A7: R237.1 U1.AB15(DDR3_A07) U27.M2(A7) U39.M2(A7) U45.M2(A7) U49.M2(A7) U52.M2(A7)
DDR_A8: R247.1 U1.AC17(DDR3_A08) U27.N8(A8) U39.N8(A8) U45.N8(A8) U49.N8(A8) U52.N8(A8)
DDR_A9: R241.1 U1.AB17(DDR3_A09) U27.M3(A9) U39.M3(A9) U45.M3(A9) U49.M3(A9) U52.M3(A9)
DDR_A10: R306.1 U1.AB14(DDR3_A10) U27.H7(A10/AP) U39.H7(A10/AP) U45.H7(A10/AP) U49.H7(A10/AP) U52.H7(A10/AP)
DDR_A11: R305.1 U1.AA16(DDR3_A11) U27.M7(A11) U39.M7(A11) U45.M7(A11) U49.M7(A11) U52.M7(A11)
DDR_A12: R307.1 U1.AA17(DDR3_A12) U27.K7(A12/BC#) U39.K7(A12/BC#) U45.K7(A12/BC#) U49.K7(A12/BC#) U52.K7(A12/BC#)
DDR_A13: R309.1 U1.AA12(DDR3_A13) U27.N3(A13) U39.N3(A13) U45.N3(A13) U49.N3(A13) U52.N3(A13)
DDR_A14: R308.1 U1.Y17(DDR3_A14) U27.N7(A14) U39.N7(A14) U45.N7(A14) U49.N7(A14) U52.N7(A14)
DDR_A15: R213.1 U1.Y16(DDR3_A15) U27.J7(A15) U39.J7(A15) U45.J7(A15) U49.J7(A15) U52.J7(A15)
DDR_BA0: R212.1 U1.AA14(DDR3_BA0) U27.J2(BA0) U39.J2(BA0) U45.J2(BA0) U49.J2(BA0) U52.J2(BA0)
DDR_BA1: R214.1 U1.AB13(DDR3_BA1) U27.K8(BA1) U39.K8(BA1) U45.K8(BA1) U49.K8(BA1) U52.K8(BA1)
DDR_BA2: R211.1 U1.AD17(DDR3_BA2) U27.J3(BA2) U39.J3(BA2) U45.J3(BA2) U49.J3(BA2) U52.J3(BA2)
DDR_CAS#: R207.1 U1.AC13(DDR3_CASN) U27.G3(CAS#) U39.G3(CAS#) U45.G3(CAS#) U49.G3(CAS#) U52.G3(CAS#)
DDR_CB00: U1.AA11(DDR3_CB00) U52.B3(DQ0)
DDR_CB01: U1.AB11(DDR3_CB01) U52.C7(DQ1)
DDR_CB02: U1.AC11(DDR3_CB02) U52.C2(DQ2)
DDR_CB03: U1.AC12(DDR3_CB03) U52.C8(DQ3)
DDR_CBDQM: U1.Y11(DDR3_CBDQM) U52.B7(DM/TDQS)
DDR_CBDQS: U1.AE12(DDR3_CBDQS_P) U52.C3(DQS)
DDR_CBDQS#: U1.AD12(DDR3_CBDQS_N) U52.D3(DQS#)
DDR_CE1Z: TP155.1(TP) U1.AB12(DDR3_CEN1)
DDR_CK: R216.1 U1.AE15(DDR3_CLKOUT_P0) U27.F7(CK) U39.F7(CK) U45.F7(CK) U49.F7(CK) U52.F7(CK)
DDR_CK#: R217.1 U1.AD15(DDR3_CLKOUT_N0) U27.G7(CK#) U39.G7(CK#) U45.G7(CK#) U49.G7(CK#) U52.G7(CK#)
DDR_CKE: R210.1 U1.AB18(DDR3_CKE0) U27.G9(CKE) U39.G9(CKE) U45.G9(CKE) U49.G9(CKE) U52.G9(CKE)
DDR_CKE1: TP154.1(TP) U1.AC18(DDR3_CKE1)
DDR_CLKN_LVDS_100MHZ: R18.2 U1.AD24(DDR_CLK_N)
DDR_CLKP_LVDS_100MHZ: R17.2 U1.AE24(DDR_CLK_P)
DDR_CS#: R209.1 U1.AD13(DDR3_CEN0) U27.H2(CS#) U39.H2(CS#) U45.H2(CS#) U49.H2(CS#) U52.H2(CS#)
DDR_DM0: U1.AB4(DDR3_DQM0) U27.B7(DM/TDQS)
DDR_DM1: U1.AA5(DDR3_DQM1) U39.B7(DM/TDQS)
DDR_DM2: U1.AC8(DDR3_DQM2) U45.B7(DM/TDQS)
DDR_DM3: U1.AA9(DDR3_DQM3) U49.B7(DM/TDQS)
DDR_DQ0: U1.AD2(DDR3_D00) U27.B3(DQ0)
DDR_DQ1: U1.AA4(DDR3_D05) U27.C7(DQ1)
DDR_DQ2: U1.Y4(DDR3_D01) U27.C2(DQ2)
DDR_DQ3: U1.AD3(DDR3_D06) U27.C8(DQ3)
DDR_DQ4: U1.AC3(DDR3_D02) U27.E3(NF/DQ4)
DDR_DQ5: U1.AE3(DDR3_D04) U27.E8(NF/DQ5)
DDR_DQ6: U1.AB3(DDR3_D07) U27.D2(NF/DQ6)
DDR_DQ7: U1.AC2(DDR3_D03) U27.E7(NF/DQ7)
DDR_DQ8: U1.Y5(DDR3_D13) U39.B3(DQ0)
DDR_DQ9: U1.AC5(DDR3_D11) U39.C7(DQ1)
DDR_DQ10: U1.AA6(DDR3_D08) U39.C2(DQ2)
DDR_DQ11: U1.AB5(DDR3_D15) U39.C8(DQ3)
DDR_DQ12: U1.Y7(DDR3_D09) U39.E3(NF/DQ4)
DDR_DQ13: U1.AB6(DDR3_D12) U39.E8(NF/DQ5)
DDR_DQ14: U1.Y6(DDR3_D10) U39.D2(NF/DQ6)
DDR_DQ15: U1.AC4(DDR3_D14) U39.E7(NF/DQ7)
DDR_DQ16: U1.AC6(DDR3_D21) U45.B3(DQ0)
DDR_DQ17: U1.AA8(DDR3_D20) U45.C7(DQ1)
DDR_DQ18: U1.AA7(DDR3_D19) U45.C2(DQ2)
DDR_DQ19: U1.AD7(DDR3_D23) U45.C8(DQ3)
DDR_DQ20: U1.AC7(DDR3_D18) U45.E3(NF/DQ4)
DDR_DQ21: U1.AE7(DDR3_D22) U45.E8(NF/DQ5)
DDR_DQ22: U1.AB8(DDR3_D17) U45.D2(NF/DQ6)
DDR_DQ23: U1.AB7(DDR3_D16) U45.E7(NF/DQ7)
DDR_DQ24: U1.Y8(DDR3_D31) U49.B3(DQ0)
DDR_DQ25: U1.AE10(DDR3_D25) U49.C7(DQ1)
DDR_DQ26: U1.AD10(DDR3_D26) U49.C2(DQ2)
DDR_DQ27: U1.AC10(DDR3_D27) U49.C8(DQ3)
DDR_DQ28: U1.AB9(DDR3_D30) U49.E3(NF/DQ4)
DDR_DQ29: U1.AB10(DDR3_D29) U49.E8(NF/DQ5)
DDR_DQ30: U1.AA10(DDR3_D24) U49.D2(NF/DQ6)
DDR_DQ31: U1.AC9(DDR3_D28) U49.E7(NF/DQ7)
DDR_DQS0: U1.AD1(DDR3_DQS0_P) U27.C3(DQS)
DDR_DQS0#: U1.AE2(DDR3_DQS0_N) U27.D3(DQS#)
DDR_DQS1: U1.AD4(DDR3_DQS1_P) U39.C3(DQS)
DDR_DQS1#: U1.AE4(DDR3_DQS1_N) U39.D3(DQS#)
DDR_DQS2: U1.AE6(DDR3_DQS2_P) U45.C3(DQS)
DDR_DQS2#: U1.AD6(DDR3_DQS2_N) U45.D3(DQS#)
DDR_DQS3: U1.AE9(DDR3_DQS3_P) U49.C3(DQS)
DDR_DQS3#: U1.AD9(DDR3_DQS3_N) U49.D3(DQS#)
DDR_DVDD18: FB6.1 U17.N6(DDR_DVDD18#N6) U17.N9(DDR_DVDD18#N9) U17.N10(DDR_DVDD18#N10) U17.P7(DDR_DVDD18#P7) U17.P8(DDR_DVDD18#P8) U17.P9(DDR_DVDD18#P9) U17.P10(DDR_DVDD18#P10) U17.R7(DDR_DVDD18#R7) U17.R8(DDR_DVDD18#R8) U17.R9(DDR_DVDD18#R9)
DDR_ODT: R215.1 U1.AA13(DDR3_ODT0) U27.G1(ODT) U39.G1(ODT) U45.G1(ODT) U49.G1(ODT) U52.G1(ODT)
DDR_ODT1: TP153.1(TP) U1.Y12(DDR3_ODT1)
DDR_RAS#: R208.1 U1.AE13(DDR3_RASN) U27.F3(RAS#) U39.F3(RAS#) U45.F3(RAS#) U49.F3(RAS#) U52.F3(RAS#)
DDR_RESET#: R443.2 R723.1 U1.Y18(DDR3_RESETN) U27.N2(RESET#) U39.N2(RESET#) U45.N2(RESET#) U49.N2(RESET#) U52.N2(RESET#)
DDR_WE#: R206.1 U1.Y13(DDR3_WEN) U27.H3(WE#) U39.H3(WE#) U45.H3(WE#) U49.H3(WE#) U52.H3(WE#)
DIP_SW_B0: R176.2 SW3.1 U20.P4(PH0/EPI0S0/U0RTS)
DIP_SW_B1: R184.2 SW3.2 U20.R2(PH1/EPI0S1/U0CTS)
DIP_SW_B2: R191.2 SW3.3 U20.R1(PH2/EPI0S2/U0DCD)
DIP_SW_B3: R198.2 SW3.4 U20.T1(PH3/EPI0S3/U0DSR)
DIR: R499.2 R741.1 U67.1(1DIR) U67.24(2DIR)
DISP_EN: J22.31 R471.1 R728.2
DSS_3V3: C297.1 C298.1 C299.1 C300.1 C301.1 C302.1 C304.1 C306.1 C309.1 R520.2 R809.2 R858.2 U80.5(VCC) U81.C3(VCC#C3) U81.C4(VCC#C4) U81.F3(VCC#F3) U81.F4(VCC#F4) U81.L3(VCC#L3) U81.L4(VCC#L4) U81.P3(VCC#P3) U81.P4(VCC#P4) U82.C3(VCC#C3) U82.C4(VCC#C4) U82.F3(VCC#F3) U82.F4(VCC#F4) U82.L3(VCC#L3) U82.L4(VCC#L4) U82.P3(VCC#P3) U82.P4(VCC#P4)
EEPROM_A1: R315.1 R698.2 U38.2(A1)
EEPROM_A2: R321.2 R701.1 U38.3(A2)
EEPROM_WP: R318.1 U33.18(B4) U38.7(WP)
ELF1: C254.1 R461.1 U62.41(ELF)
EMA_A0: RA14.3 U17.C14(EMA_A[0]/GP5[0])
EMA_A1: RA14.1 U17.D15(EMA_A[1]/GP5[1])
EMA_A2: RA14.4 U17.B14(EMA_A[2]/GP5[2])
EMA_A3: RA14.2 U17.D14(EMA_A[3]/GP5[3])
EMA_A4: RA11.1 U17.A14(EMA_A[4]/GP5[4])
EMA_A5: RA11.2 U17.C13(EMA_A[5]/GP5[5])
EMA_A6: RA11.4 U17.E13(EMA_A[6]/GP5[6])
EMA_A7: RA11.3 U17.B13(EMA_A[7]/GP5[7])
EMA_A8: RA5.3 U17.A13(EMA_A[8]/GP5[8])
EMA_A9: RA5.4 U17.D12(EMA_A[9]/GP5[9])
EMA_A10: RA5.1 U17.C12(EMA_A[10]/GP5[10])
EMA_A11: RA5.2 U17.B12(EMA_A[11]/GP5[11])
EMA_A12: RA12.3 U17.D13(EMA_A[12]/GP5[12])
EMA_BA0: RA12.2 U17.C15(EMA_BA[0]/GP2[8])
EMA_BA1: RA12.4 U17.A15(EMA_BA[1]/GP2[9])
EMA_D0: RA2.8 U17.C9(EMA_D[0]/GP4[8])
EMA_D1: RA2.6 U17.A8(EMA_D[1]/GP4[9])
EMA_D2: RA2.7 U17.B8(EMA_D[2]/GP4[10])
EMA_D3: RA2.5 U17.E8(EMA_D[3]/GP4[11])
EMA_D4: RA4.8 U17.B5(EMA_D[4]/GP4[12])
EMA_D5: RA4.7 U17.E7(EMA_D[5]/GP4[13])
EMA_D6: RA4.6 U17.C6(EMA_D[6]/GP4[14])
EMA_D7: RA4.5 U17.D7(EMA_D[7]/GP4[15])
EMA_D8: RA3.8 U17.E10(EMA_D[8]/GP3[0])
EMA_D9: RA3.7 U17.D9(EMA_D[9]/GP3[1])
EMA_D10: RA3.6 U17.A7(EMA_D[10]/GP3[2])
EMA_D11: RA3.5 U17.D6(EMA_D[11]/GP3[3])
EMA_D12: RA1.8 U17.A6(EMA_D[12]/GP3[4])
EMA_D13: RA1.6 U17.B6(EMA_D[13]/GP3[5])
EMA_D14: RA1.7 U17.C7(EMA_D[14]/GP3[6])
EMA_D15: RA1.5 U17.E6(EMA_D[15]/GP3[7])
EMMC_RSTN: R278.1 U35.16(B6) U36.1(A)
EMMC_RSTN_AND: U34.3(A) U36.4(Y)
EMU_TVD: J8.5 R142.1
EMULED1: Q6.1(G) R36.1 R89.2
EMULED2: Q7.1(G) R37.1 R90.2
EN_3V3_CONN: R826.1 R851.1 R909.1 U116.6(EN)
EN_3V3_DCIN: R900.1 R901.2 R907.1 R908.1 U141.6(EN)
EN_DCDC: R76.2 U6.8(EN_DCDC)
EN_LDO1: C373.2 R47.2 U6.1(EN_LDO1)
EN_LDO2: C376.2 R64.1 U6.2(EN_LDO2)
ETH1_XI: C335.2 U92.46(XI) Y9.2
ETH1_XO: C334.2 U92.45(XO) Y9.1
ETH_RSTN: R276.1 U35.18(B4) U89.1(A)
ETH_RSTN_AND: R529.2 U88.2(A) U89.4(Y)
