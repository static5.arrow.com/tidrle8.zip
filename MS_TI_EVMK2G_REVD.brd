# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N19748861: length 13.9
  TOP w0.102: U20.B3 71.43,201.01 71.13,201.31
  TOP w0.127: 71.13,201.31 68.52,201.31 68.02,201.82 62.86,201.82 61.72,202.96 61.72,204.1 TP79.1
N19748877: length 12.3
  TOP w0.102: U20.B2 70.93,200.26 71.21,200.54 71.21,200.85 71.05,201.01 71.01,201.01 70.97,201.06 68.83,201.06
  TOP w0.127: 68.83,201.06 68.33,201.06 68.07,201.31 62.74,201.31 TP80.1
N19749721: length 2.9
  TOP w0.127: LD10.1 61.87,137.28 Q8.3
N19749727: length 2.2
  TOP w0.127: Q8.1 60.92,131.22 60.86,131.16 R39.1
N19749733: length 2.5
  TOP w0.127: LD10.2 v2(61.75,140.39)
  BOTTOM w0.127: R589.2 v2(61.75,140.39)
N19749927: length 2.9
  TOP w0.127: LD13.1 Q11.3
N19749933: length 2.1
  TOP w0.127: Q11.1 56.73,131.16 56.79,131.09 R42.1
N19749935: length 2.7
  TOP w0.127: LD13.2 v2(57.68,140.64)
  BOTTOM w0.127: R588.2 v2(57.68,140.64)
N19752176: length 4.4
  TOP w0.102: U20.W15 77.43,191.14 78.41,190.16
  TOP w0.127: R226.1 79.69,188.88 78.41,190.16
N19752383: length 2
  TOP w0.127: U21.1 82.39,187.1 R227.1
N19760880: length 19.2
  TOP w0.127: U1.Y9 v1(167.61,121.81)
  BOTTOM w0.127: 161.99,122.32 164.11,122.32 165.02,121.4 165.04,121.4 165.05,121.41 165.37,121.41 165.38,121.4 166.64,121.4 166.65,121.41 166.97,121.41 166.98,121.4 167.2,121.4 v1(167.61,121.81)
  BOTTOM w0.254: 161.99,122.32 161.51,122.8 159.16,122.8 158.7,123.26 158.7,127.93 158.09,128.54 156.86,128.54 R403.1
N19771684: length 4.3
  TOP w0.127: U20.A11 75.32,200.84 v1(75.32,201.3)
  BOTTOM w0.102: 75.18,202.4 75.18,201.44 v1(75.32,201.3)
  BOTTOM w0.127: 75.18,202.4 75.18,203.04 75.92,203.77 76.17,204.03 76.17,204.03 76.41,204.27 R164.1
N19771691: length 7.9
  TOP w0.102: U20.B10 74.65,200.51 74.65,200.85 74.69,200.89 74.69,201.87
  TOP w0.127: 74.69,201.87 74.68,201.89 74.68,202.34 74.4,202.61 74.04,202.61 74.03,202.61 72.85,202.61 72.16,203.29 71.41,203.29 R162.1
N19771705: length 4.8
  TOP w0.102: v1(74.3,201.31) 74.43,201.17 U20.B9
  BOTTOM w0.127: v1(74.29,201.31) 73.66,201.31 72.52,202.45 R161.1
N19771712: length 6
  TOP w0.102: U20.B11 75.71,200.51 75.71,200.85 75.7,200.85 75.7,201.53 75.7,201.54 75.7,201.56 75.59,201.67 75.59,202.55
  TOP w0.127: v1(75.64,202.66) 75.59,202.61 75.59,202.55
  BOTTOM w0.127: R163.1 77.93,203.72 77.75,203.54 76.53,203.54 v1(75.64,202.66)
N19771719: length 6.2
  TOP w0.127: U20.C10 v1(74.45,199.73)
  BOTTOM w0.127: v1(74.45,199.73) 74.21,199.96 73.86,199.96 70.99,202.83 R160.1
N19771726: length 6.3
  TOP w0.127: U20.T12 75.93,193.4 75.51,193.82 v1(75.51,193.97) ; R221.1 v2(76.33,189.72)
  BOTTOM w0.102: v1(75.51,193.97) 75.53,193.97 75.89,193.61 75.89,191.64 76.33,191.2 v2(76.33,189.72)
N19776321: length 24.6
  TOP w0.127: R450.1 195.57,103.58 193.65,101.67 191.01,101.67 189.99,102.68 189.99,102.74 189.72,103.01 189.66,103.01 189.66,103.01 189.34,103.01 188.79,102.46 186.35,102.46 186.04,102.77 186.02,102.77 185.9,102.88 185.67,102.88 185.29,103.27 182.45,103.27 181.45,104.27 181.43,104.27 180.72,104.98 180.72,105.54 180.41,105.85 180.41,109.81 U1.E24
N19776412: length 6
  TOP w0.127: v1(72.8,193.69) 72.93,193.56 U20.T6 ; R220.1 v2(73.03,189.26)
  BOTTOM w0.102: 73.15,190.16 73.15,191.58 72.8,191.94 v1(72.8,193.69)
  BOTTOM w0.127: 73.15,190.16 73.15,189.39 v2(73.03,189.26)
N19776797: length 4.2
  TOP w0.127: R219.1 59.65,159.41 59.28,159.04 J15.3
N19776809: length 3.9
  TOP w0.127: J15.1 64.36,159.17 64.12,159.41 R218.1
N19849959: length 2.6
  TOP w0.127: SW12.1 5.74,50.15 5.98,50.4 R515.1
N19921815: length 7.6
  TOP w0.127: R71.1 128.02,232.93 128.42,233.34 v2(130.51,233.34) U7.4
  BOTTOM w0.127: R607.2 130.51,231.86 v2(130.51,233.34)
N19935028: length 37.4
  TOP w0.127: v2(165.23,147.63) 165.23,148.73 164.99,148.97 R365.2 ; U1.W5 v1(169.21,125.01)
  L03_SIG1 w0.102: 170.26,134.89 170.26,134.48 170.42,134.32 170.42,129.48 171.48,128.43 171.48,126.25 171.19,125.96 171.19,125.66 170.93,125.39 170.65,125.39 170.43,125.17 170.43,124.06 170.43,124.05 170.43,124.05 170.2,123.81 169.82,123.81 169.62,124.02 169.62,124.35 169.21,124.76 v1(169.21,125.01)
  L03_SIG1 w0.127: 170.26,134.89 170.26,139.51 169.34,140.43 169.34,144.21 171.18,146.05 171.18,147.16 169.46,148.88 166.2,148.88 165.23,147.91 v2(165.23,147.63)
N19935032: length 27.1
  TOP w0.127: v2(166.92,147.5) 167.13,147.72 167.13,148.6 166.77,148.97 R366.2 ; U1.U5 v1(170.01,125.81)
  L03_SIG1 w0.102: v1(170.01,125.81) 170.01,126.01 170.39,126.39 170.39,128.33 169.86,128.86 169.86,134.06 169.41,134.51 169.41,134.89
  L03_SIG1 w0.127: v2(166.92,147.5) 167.09,147.33 168.47,147.33 168.77,147.03 168.77,136.73 169.41,136.09 169.41,134.89
N19935171: length 24.4
  TOP w0.127: U1.W4 v1(169.21,126.61)
  L03_SIG1 w0.102: 168.82,134.89 168.82,127.23 169.16,126.89 169.16,126.66 v1(169.21,126.61)
  L03_SIG1 w0.127: 168.82,134.89 168.82,135.14 167.27,136.69 167.27,143.07 166.69,143.65 162.98,143.65 v2(162.18,142.85)
  BOTTOM w0.127: R711.2 v2(162.18,142.85)
N19935173: length 25.4
  TOP w0.127: U1.V6 v1(170.01,124.21)
  L03_SIG1 w0.102: v1(170.01,124.21) 170.01,124.47 169.62,124.85 169.62,125.15 169.37,125.4 169.08,125.4 169.02,125.45 169.02,125.46 168.83,125.66 168.83,126.84 168.64,127.03 168.25,127.03 168.02,127.25 168.02,128.41 168.27,128.67 168.27,133.87 167.69,134.46 167.21,134.46 166.78,134.89
  L03_SIG1 w0.127: v2(163.7,142.85) 164.22,143.37 165.51,143.37 165.85,143.03 165.85,135.82 166.78,134.89
  BOTTOM w0.127: R710.2 v2(163.7,142.85)
N19935221: length 17.7
  TOP w0.127: R373.2 v2(175.89,142.98) ; v1(174.01,129.88) 174.01,128.21 U1.M2
  L08_SIG2 w0.102: 174.4,133.52 174.4,130.27 v1(174.01,129.88) ; 174.24,134.03 174.24,134.89
  L08_SIG2 w0.127: v2(175.89,142.98) 176.5,142.37 176.5,140.1 174.24,137.84 174.24,134.89 ; 174.4,133.52 174.4,133.53 174.4,133.86 174.4,133.86 174.4,133.87 174.24,134.03
N19935328: length 12.5
  TOP w0.127: U1.R2 171.61,128.21 171.61,132.35 171.18,132.78 171.18,133.32 v1(170.81,133.69)
  BOTTOM w0.102: v1(170.81,133.69) 170.11,133.69 169.29,134.51 169.29,134.89
  BOTTOM w0.127: 169.29,134.89 169.29,138.05 R716.2
N19935623: length 8.2
  TOP w0.102: 77.43,194.49 77.43,194.36 v1(77.37,194.3)
  TOP w0.127: 77.43,194.49 U20.N15
  BOTTOM w0.102: v1(77.37,194.3) 77.39,194.28 77.39,194.37 78.05,195.04 78.66,195.04 78.84,194.86 78.84,194.02 80.06,192.8 80.82,192.8 80.9,192.88
  BOTTOM w0.127: 80.9,192.88 82.09,194.07 R200.2
N19935654: length 7.6
  TOP w0.127: U20.T14 76.93,193.53 77.01,193.61 v1(77.17,193.61)
  BOTTOM w0.102: 79.25,193.13 78.21,194.17 77.8,194.17 77.53,193.91 77.53,193.82 77.33,193.61 v1(77.17,193.61)
  BOTTOM w0.127: R203.2 82.41,193.18 81.66,193.18 81.05,192.57 79.81,192.57 79.25,193.13
N19936542: length 19.8
  TOP w0.127: U20.M16 77.78,195.23 v1(77.51,195.5) ; TP181.1 v2(90.3,197.25)
  L03_SIG1 w0.102: v1(77.51,195.5) 76.65,196.36 76.27,196.36 76.05,196.58 76.05,196.9 76.32,197.17 77.63,197.17 77.68,197.22 77.99,197.22 78.04,197.17 79.58,197.17 80.64,198.22
  L03_SIG1 w0.127: v2(90.3,197.25) 89.79,196.74 83.69,196.74 81.84,198.59 81.68,198.59 81.67,198.6 81.02,198.6 80.64,198.22
N19936548: length 7.7
  TOP w0.102: 75.76,190.16 75.76,190.77 75.43,191.09 U20.V11
  TOP w0.127: TP180.1 76.33,186.4 75.59,187.14 75.59,189.71 75.76,189.88 75.76,190.16
N19936677: length 2.8
  TOP w0.127: U95.7 293.43,41.88 292.99,42.32 R553.1
N19998418: length 12.6
  TOP w0.127: U20.T19 79.69,193.23 80.04,192.89 80.04,191.94 80.26,191.71 v1(80.26,191.66) ; TP97.1 v2(78.73,183.4)
  L08_SIG2 w0.127: v2(78.73,183.4) 78.58,183.55 78.58,187.11 81.03,189.55 81.03,190.9 v1(80.26,191.66)
N20088320: length 9.2
  TOP w0.102: 71.93,201.13 71.21,201.84
  TOP w0.127: 71.21,201.84 68.78,201.84 68.17,202.45 64.39,202.45 TP56.1 ; U20.A4 71.93,201.13
N20088340: length 20.1
  TOP w0.102: 241.66,169.28 242.57,170.19 243.54,170.19 U32.L2
  TOP w0.127: 241.66,169.28 240.89,168.51 240.89,166.33 240.61,166.05 240.61,162.22 239.83,161.43 238.63,161.43 238.17,161.89 233.12,161.89 v2(232.64,161.41)
  BOTTOM w0.127: R703.1 233.07,160.53 233.07,160.97 v2(232.64,161.41)
N20088352: length 22.1
  TOP w0.102: v1(244.37,172.65) 244.52,172.79 U32.G3
  TOP w0.127: R340.1 v2(233.81,158.64)
  L03_SIG1 w0.127: v2(233.81,158.64) 234.82,159.65 234.82,166.54 240.89,172.61 244.33,172.61 v1(244.37,172.65)
N20088355: length 19.9
  TOP w0.102: U32.L4 v1(244.84,170.84)
  TOP w0.127: R338.1 v2(254,159.02)
  L03_SIG1 w0.127: v2(254,159.02) 254,161.53 250.7,164.84 247.32,164.84 244.35,167.81 244.35,170.63 244.56,170.84 v1(244.84,170.84)
N20088489: length 27.7
  TOP w0.102: U32.H4 v1(244.84,172.14)
  L03_SIG1 w0.127: TP112.1 231.83,153.86 236.12,158.16 236.12,167.17 240.87,171.92 244.62,171.92 v1(244.84,172.14)
N20088492: length 13.4
  TOP w0.102: U32.C7 247.44,176.04 248.28,176.04
  TOP w0.127: 248.28,176.04 248.6,176.04 251.29,178.73 253.14,178.73 255.8,181.4 256.16,181.4 256.64,181.88 R245.1
N20088495: length 18.5
  TOP w0.102: v1(244.84,170.19) 244.52,170.51 U32.L3
  TOP w0.127: v2(256.13,160.54) 255.52,159.94 R341.1
  L03_SIG1 w0.127: v1(244.84,170.19) 244.98,170.05 244.98,169.23 245.16,169.05 245.16,167.78 247.62,165.32 250.85,165.32 255.63,160.54 v2(256.13,160.54)
N20165134: length 1.9
  TOP w0.127: R236.1 104.62,185.05 104.61,185.07 U23.6
N20247908: length 6.6
  TOP w0.127: U82.L2 v1(129.65,65.72) ; R510.1 v2(133.15,67.87)
  L03_SIG1 w0.127: v1(129.65,65.72) 130.05,66.11 130.05,66.35 130.05,66.99 130.92,67.87 v2(133.15,67.87)
N20273568: length 4.3
  TOP w0.127: U82.M2 v1(128.85,65.72) ; R508.1 v2(130.1,67.87)
  L03_SIG1 w0.127: v1(128.85,65.72) 129.26,66.12 129.26,67.03 v2(130.1,67.87)
N20324932: length 4.7
  TOP w0.102: 78.43,200.85 U20.A17
  TOP w0.127: 78.43,200.85 78.8,201.22 78.8,202.44 80.65,204.28 R153.2
N20324951: length 11.2
  TOP w0.102: U20.B17 v1(78.43,199.81)
  TOP w0.127: v2(83.74,204.92) 83.38,204.92 83.36,204.94 83.01,204.94 82.99,204.92 82.62,204.92 R154.2
  L03_SIG1 w0.102: v1(78.43,199.81) 79.35,199.81 79.65,200.12 80.9,200.12
  L03_SIG1 w0.127: v2(83.74,204.92) 83.9,204.76 83.9,202.66 81.36,200.12 80.9,200.12
N20326127: length 10.8
  TOP w0.102: U20.U12 75.9,192.7 75.46,192.7 v1(75.41,192.75)
  TOP w0.127: TP86.1 79.02,185.05 v2(79.15,185.18)
  BOTTOM w0.102: v1(75.41,192.75) 75.41,190.85 75.69,190.57 75.69,190.16
  BOTTOM w0.127: v2(79.15,185.18) 78.84,185.49 78.71,185.49 75.69,188.51 75.69,190.16
N20326675: length 13.8
  TOP w0.102: U20.J1 70.1,196.73
  TOP w0.127: TP58.1 58.23,195.15 60.39,195.15 61.44,196.2 68.3,196.2 68.83,196.73 70.1,196.73
N20326684: length 12.5
  TOP w0.102: U20.J2 70.65,197.01 70.31,197.01 70.29,196.99 69.07,196.99
  TOP w0.127: 69.07,196.99 68.63,196.99 68.12,196.48 64.64,196.48 63.75,197.37 62.84,197.37 61.95,196.48 60.2,196.48 TP59.1
N20327036: length 16.4
  TOP w0.102: 68.83,197.59 68.98,197.45 70.65,197.45 U20.G2
  TOP w0.127: 68.83,197.59 68.44,197.98 60.81,197.98 60.14,198.66 56.4,198.66 TP75.1
N20327038: length 19.1
  TOP w0.102: U20.G1 69.1,197.73 68.83,198
  TOP w0.127: 68.83,198 68.54,198.29 64.95,198.29 64.92,198.26 64.56,198.26 64.53,198.29 61.06,198.29 60.45,198.9 55.37,198.9 54.66,198.19 54.66,196.81 TP74.1
N20327047: length 14.2
  TOP w0.127: TP76.1 58.31,196.99 61.72,196.99 62.47,197.74 68.14,197.74 68.65,197.23 U20.H2
N20327049: length 12.8
  TOP w0.127: TP77.1 60.52,197.88 60.9,197.5 v2(61.34,197.5) ; v1(71.42,197.73) 71.43,197.72 U20.H3
  L03_SIG1 w0.102: v1(71.42,197.73) 68.83,197.73
  L03_SIG1 w0.127: v2(61.34,197.5) 62.15,198.31 68,198.31 68.58,197.73 68.83,197.73
N20327072: length 11.9
  TOP w0.127: TP66.1 66.56,206.9 70.42,203.04 71.91,203.04 73.43,201.51 U20.A7
N20327098: length 14.1
  TOP w0.102: 72.99,201.5 73.15,201.34 73.15,200.85 73.15,200.85 73.15,200.61 73.15,200.61 73.15,200.51 U20.B7
  TOP w0.127: 72.99,201.5 71.69,202.8 70.27,202.8 67.31,205.75 63.75,205.75 TP67.1
N20333819: length 6
  TOP w0.102: 74.96,202.55 74.96,201.47 74.94,201.46 74.94,200.74 U20.A10
  TOP w0.127: TP54.1 74.8,205.75 74.8,202.71 74.96,202.55
N20333845: length 6.3
  TOP w0.127: U20.M4 72.25,195.23 72.64,195.63 v1(72.64,195.66)
  BOTTOM w0.102: 68.83,195.98 69.8,195.98 70.56,195.21 72.23,195.21 72.64,195.63 v1(72.64,195.66)
  BOTTOM w0.127: R195.1 68.05,195.54 68.48,195.98 68.83,195.98
N20334677: length 4.3
  TOP w0.102: 77.93,200.83 U20.A16
  TOP w0.127: R166.1 79.25,203.82 78.36,202.94 78.36,201.26 77.93,200.83
N20334698: length 4.7
  TOP w0.102: U20.B16 77.92,200.23 77.65,200.5 77.65,200.9 78.03,201.28 78.03,202.55
  TOP w0.127: 78.03,202.55 78.03,204.14 R174.1
N20368231: length 2.7
  TOP w0.127: R604.1 207.16,232.04 207.19,232.02 J5.B9
N20368804: length 3.3
  TOP w0.127: v2(218.19,236.23) 217.74,236.23 217.53,236.02 J5.A5
  BOTTOM w0.127: R598.1 217.93,235.98 v2(218.19,236.23)
N20391651: length 3.1
  TOP w0.127: R507.1 128.57,66.8 U82.M1
N20474037: length 2.4
  TOP w0.127: J16.1 74.88,158.87 74.82,158.93 R264.1
N20474249: length 2.5
  TOP w0.127: R252.1 J16.3
N20476232: length 4.4
  TOP w0.127: U33.9 63.48,169.86 v2(62.98,169.36)
  BOTTOM w0.127: v2(62.98,169.36) 62.48,169.85 62.48,170.54 61.81,171.21 R312.2
N20518193: length 3.3
  TOP w0.127: v2(130.51,223.96) U7.5
  BOTTOM w0.127: R610.2 130.51,225.22 v2(130.51,223.96)
N20519274: length 5.4
  TOP w0.127: C14.2 136.02,233.19 135.64,233.57 134.49,233.57 134.32,233.39 U7.1
N21103341: length 24.2
  TOP w0.127: U1.V4 v1(169.21,125.81)
  L03_SIG1 w0.102: 169.1,134.89 169.1,134.44 169.6,133.95 169.6,126.2 v1(169.21,125.81)
  L03_SIG1 w0.127: 169.1,134.89 169.1,135.32 167.55,136.87 167.55,143.08 168.27,143.8 v2(168.27,146.83)
  BOTTOM w0.127: v2(168.27,146.83) 168.02,147.08 R708.2
N21103343: length 26.5
  TOP w0.127: U1.V5 v1(170.01,125.01)
  L03_SIG1 w0.102: v1(170.01,125.01) 170.01,125.22 170.43,125.64 170.43,125.99 170.63,126.19 170.93,126.19 171.2,126.46 171.2,127.9 170.14,128.96 170.14,134.11 169.69,134.57 169.69,134.89
  L03_SIG1 w0.127: 169.69,134.89 169.69,136.21 169.06,136.84 169.06,145.33 v2(170.69,146.95)
  BOTTOM w0.127: v2(170.69,146.95) 170.69,147.74 170.35,148.08 R707.2
N21103450: length 3.1
  TOP w0.127: U38.5 197.83,170.93 197.03,171.74 R265.1
N21103457: length 2.8
  TOP w0.127: U38.6 v2(197.41,170.28)
  BOTTOM w0.127: v2(197.41,170.28) 197.34,170.21 R700.1
N21115682: length 7.6
  TOP w0.127: J8.13 271.02,75.28 v2(270.97,75.33)
  BOTTOM w0.127: v2(270.97,75.33) 269.82,76.47 267.77,76.47 267.21,77.03 R240.2
N21115817: length 14
  TOP w0.127: v2(271.04,76.75) 271.02,76.77 J8.14
  BOTTOM w0.127: v2(271.04,76.75) 271.45,77.15 272.69,77.15 273,76.85 273,74.06 271.07,72.13 267.98,72.13 267.23,72.87 R243.2
N21135598: length 1.9
  TOP w0.127: U62.14 140.75,85.01 140.46,84.72 TP160.1
N21135600: length 2.8
  TOP w0.127: TP161.1 141.25,85.01 U62.15
N21169756: length 16.1
  TOP w0.102: 72.43,191.41 72.43,192 72.43,192 U20.V5
  TOP w0.127: 72.43,191.41 71.09,190.08 71.09,187.76 67.58,184.25 63.58,184.25 TP20.1
N21170847: length 3.4
  TOP w0.127: R302.2 45.47,175.02 45.57,174.92 U31.7
N21170992: length 5.6
  TOP w0.127: U31.2 v2(46.11,178.17) 43.98,178.17 R282.1
  BOTTOM w0.127: v2(46.11,178.17) 43.98,178.17 R282.1
N21171020: length 6
  TOP w0.127: R291.1 44.92,176.67 45.33,177.08 v2(45.33,177.52) U31.3
  BOTTOM w0.127: v2(45.33,177.52) 45.33,177.08 44.92,176.67 R291.1
N21171769: length 11.2
  TOP w0.102: 73.71,191.19 73.71,191.95 U20.V7
  TOP w0.127: 73.71,191.19 72.29,189.76 72.29,186.1 TP21.1
N21171778: length 11.4
  TOP w0.102: U20.W7 73.43,191.4
  TOP w0.127: TP22.1 68.33,183.15 68.33,183.78 72.01,187.47 72.01,189.88 73.43,191.3 73.43,191.4
N21184349: length 19.8
  TOP w0.102: v1(69.31,194.48) 69.49,194.66 69.57,194.66 69.77,194.86 70.3,194.86 U20.N1
  TOP w0.127: TP19.1 v2(58.29,183.56)
  BOTTOM w0.127: v2(58.29,183.56) 60.86,183.56 69.86,192.56 69.86,192.89 69.11,193.64 69.11,194.28 v1(69.31,194.48)
N21185356: length 5.1
  TOP w0.127: R493.1 137.03,83.43 136.92,83.31 R495.2 136.92,81.63 136.94,81.6 C283.2 136.94,80.17 137.19,79.92 Y8.1
N21185385: length 7.7
  TOP w0.127: R496.1 135.51,83.43 135.62,83.31 R495.1 135.62,81.86 135.19,81.43 C295.2 135.3,80.89 136.07,80.12 136.07,78.5 135.09,77.52 Y8.3
N21231083: length 2.2
  TOP w0.127: U60.8 126.49,98.77 126.51,98.78 C268.2
N21235084: length 4.3
  BOTTOM w0.508: 208.43,26.74 J14.2 ; J14.2 209.5,27.8 ; J14.2 209.5,25.67 ; J14.2 210.57,26.74
N21316200: length 8.8
  TOP w0.127: SW8.4 SW8.3 278.07,167.05 278.09,167.02 R294.2
N21319043: length 4.5
  TOP w0.127: U25.3 116.33,207.41 117.09,208.17 R222.2
N21320308: length 8
  TOP w0.127: R793.2 120.65,208.52 120.27,208.9 R311.2 R223.1 118.75,208.68 117.6,207.53 U25.2
N21499820: length 10
  TOP w0.102: U20.V10 75.21,191.95 75.21,190.91 75.49,190.63 75.49,190.16
  TOP w0.127: 75.49,190.16 75.49,189.95 75.35,189.81 75.35,187.04 75.48,186.91 75.48,184.46 74.93,183.91 TP13.1
N21500371: length 3.7
  TOP w0.127: R5.2 92.73,179.21 91.67,180.28 U24.10
N21505605: length 4.4
  TOP w0.127: R1.2 v2(89.69,114.34) 90.06,113.97 90.84,113.97 91.23,113.58 U51.24
  BOTTOM w0.127: R1.2 v2(89.69,114.34)
N21505608: length 3.6
  TOP w0.127: R497.2 v2(91.21,114.34) 91.34,114.34 91.73,113.95 U51.23
  BOTTOM w0.127: R497.2 v2(91.21,114.34)
N21505611: length 6.3
  TOP w0.127: U51.18 95.67,112.57 96.79,113.69 R3.2 v2(95.9,115.47)
  BOTTOM w0.127: R3.2 v2(95.9,115.47)
N21505922: length 2.8
  TOP w0.127: LD1.2 v2(69.75,140.6)
  BOTTOM w0.127: R12.2 v2(69.75,140.6)
N21506103: length 2.9
  TOP w0.127: LD3.2 v2(65.94,140.6)
  BOTTOM w0.127: R13.2 v2(65.94,140.6)
N21506291: length 2.8
  TOP w0.127: LD5.2 v2(80.8,140.6)
  BOTTOM w0.127: v2(80.8,140.6) R14.2
N21506486: length 2.8
  TOP w0.127: LD4.2 v2(73.69,140.6)
  BOTTOM w0.127: R15.2 v2(73.69,140.6)
N21507867: length 2.8
  TOP w0.127: LD2.2 v2(77.5,140.6)
  BOTTOM w0.127: R16.2 v2(77.5,140.6)
N21508122: length 6.6
  TOP w0.127: TP191.1 87.02,115.1 89.55,112.57 U51.1
N21508129: length 12.7
  TOP w0.127: TP192.1 82.58,117.85 88.35,112.07 U51.2
N21508178: length 5.8
  TOP w0.127: U51.8 91.73,108.57 TP9.1
N21508185: length 5.1
  TOP w0.127: U51.10 92.73,108.49 91.02,106.78 TP186.1
N21508192: length 4.8
  TOP w0.127: TP187.1 94.06,106.79 93.23,107.62 U51.11
N21508199: length 5.8
  TOP w0.127: U51.12 93.73,108.29 TP188.1
N21508206: length 8.2
  TOP w0.127: TP189.1 98.45,106.49 98.45,107.1 95.48,110.07 U51.13
N21508213: length 6.9
  TOP w0.127: TP184.1 96.9,110.57 U51.14
N21508220: length 6.1
  TOP w0.127: U51.15 99.19,111.07 TP185.1
N21690505: length 5.5
  TOP w0.127: U112.4 158.61,147.89 159.12,147.39 R784.1 v2(159.12,143.78)
  BOTTOM w0.127: R784.1 v2(159.12,143.78)
N21783594: length 4.6
  TOP w0.127: U42.3 271.02,150.51 271.21,150.7 271.21,151.84 270.76,152.29 270.14,152.29 269.62,152.81 R788.2
N21786150: length 2.4
  TOP w0.127: U43.3 251.32,149.75 R789.2
N21786851: length 3.3
  TOP w0.127: R792.2 249.32,138.86 249.66,139.21 U48.3
N21787536: length 3.1
  TOP w0.127: U44.3 238,149.49 237.74,149.75 237.26,149.75 237.14,149.62 R790.2
N21787552: length 3.4
  TOP w0.127: R791.2 238.12,140.6 238.38,140.35 U46.3
N21997071: length 7.8
  TOP w0.127: U17.F4 235.81,54.04 R173.1
N21997073: length 2.2
  TOP w0.127: R173.2 226.28,54.04 225.97,53.74 TP177.1
N22024660: length 26.9
  TOP w0.127: U17.K18 v1(247.02,50.85) ; TP178.1 v2(266.93,51.88)
  L08_SIG2 w0.102: 250.98,51.09 248.89,51.09
  L08_SIG2 w0.127: 250.98,51.09 253.47,51.09 253.9,50.66 257.35,50.66 257.66,50.36 257.66,49.8 260.38,47.08 262.33,47.08 263.32,48.07 263.32,50.31 264.9,51.88 v2(266.93,51.88) ; 248.89,51.09 248.74,50.94 247.53,50.94 247.44,50.85 v1(247.02,50.85)
N22048902: length 10.9
  TOP w0.102: U62.23 145.25,85.25 145.16,85.16 145.16,84.02 146.06,83.13 152.42,83.13 152.63,82.92 152.78,82.92 152.89,83.03 R19.1
N22048912: length 10.9
  TOP w0.102: R20.1 152.28,82.8 145.92,82.8 144.83,83.89 144.83,85.16 144.75,85.23 U62.22
N22048972: length 4
  TOP w0.127: TP162.1 141.75,84.49 U62.16
N22048974: length 5.2
  TOP w0.127: U62.17 142.25,83.97 TP163.1
N22366198: length 3
  TOP w0.127: J5.B5 207.93,236.02 207.59,236.36 R800.1
N22366201: length 2.9
  TOP w0.127: R801.1 207.29,234.84 207.47,235.02 J5.B6
N22367180: length 3.6
  TOP w0.127: U56.9 199.53,96.02 198.88,96.66 R803.2
N22367188: length 2.8
  TOP w0.127: R804.2 200.48,97.63 199.77,96.92 199.77,96.66 199.9,96.53 199.9,96.52 U56.10
N22388793: length 13.4
  TOP w0.127: v1(74.17,193.68) 74.17,193.69 73.89,193.69 U20.T7 ; TP96.1 v2(72.27,183.65)
  L08_SIG2 w0.102: 72.64,192.27 72.64,192.88 73.28,193.51 74,193.51 v1(74.17,193.68)
  L08_SIG2 w0.127: v2(72.27,183.65) 71.84,184.08 71.84,191.47 72.64,192.27
N22388802: length 14.3
  TOP w0.102: U20.V6 72.93,192.2 72.64,191.91 72.64,191.28 71.53,190.16
  TOP w0.127: TP94.1 65.66,183.91 67.69,183.91 70.61,186.83 70.61,186.83 71.37,187.59 71.37,190.01 71.53,190.16
N22388818: length 11.6
  TOP w0.127: U20.U6 72.43,193.23 v1(72.39,193.23) ; TP95.1 v2(70.97,183.91)
  L08_SIG2 w0.102: 71.57,190.16 71.57,191.7 72.42,192.55 72.42,193.21 v1(72.39,193.23)
  L08_SIG2 w0.127: 71.57,190.16 71.57,184.51 v2(70.97,183.91)
N22388827: length 12.2
  TOP w0.102: U20.W6 72.93,191.15
  TOP w0.127: 72.93,191.15 71.73,189.95 71.73,187.61 67.65,183.53 67.06,183.53 TP93.1
N22391170: length 3.7
  TOP w0.127: R808.2 SW14.1
N22515669: length 3.6
  TOP w0.127: R503.2 292.79,50.01 292.35,50.46 U75.1
N22519288: length 6.9
  TOP w0.127: R742.2 277.55,57.19 277.84,56.89 U69.2 281.31,56.89 281.49,56.71 281.49,56.45 281.28,56.24 U69.3
N22525689: length 2.5
  TOP w0.127: U84.2 284.14,60.68 R806.1
N22774183: length 22.5
  TOP w0.102: U32.L5 v1(245.49,170.84)
  L03_SIG1 w0.127: TP175.1 257.43,165.67 253.19,169.92 247.03,169.92 246.32,170.62 246.14,170.62 245.92,170.84 v1(245.49,170.84)
N22774186: length 19.1
  TOP w0.102: v1(246.14,173.44) 246.47,173.77 U32.F6
  L03_SIG1 w0.127: TP107.1 263.06,175.06 258.01,175.06 256.77,173.83 247.6,173.83 247.21,173.44 v1(246.14,173.44)
N22774189: length 22.4
  TOP w0.102: U32.G6 246.79,173.44 248.4,173.44
  TOP w0.127: v2(248.97,173.1) 248.66,173.42 248.43,173.42 248.4,173.44
  L03_SIG1 w0.127: v2(248.97,173.1) 249.31,173.45 257.12,173.45 257.47,173.79 267.25,173.79 TP111.1
N22774190: length 21.9
  TOP w0.102: v2(249.72,172.08) 249.66,172.14 248.16,172.14 248.16,172.14 247.44,172.14 U32.H7
  L03_SIG1 w0.127: TP108.1 265.45,172.08 v2(249.72,172.08)
N22774191: length 15.2
  TOP w0.102: U32.B7 247.44,176.69 248.48,176.69
  TOP w0.127: TP88.1 254.89,184.93 254.56,184.6 254.56,181.29 252.58,179.31 251.1,179.31 248.48,176.69
N22774198: length 19.9
  TOP w0.102: U32.K5 v1(245.49,171.49)
  L03_SIG1 w0.127: TP117.1 262.76,170.53 250.11,170.53 249.06,171.58 246.17,171.58 246.09,171.49 v1(245.49,171.49)
N22816314: length 2.2
  TOP w0.127: R819.1 64.92,131.64 64.99,131.71 Q15.1
N22816317: length 2.6
  TOP w0.127: LD3.1 Q15.3
N22816577: length 2.6
  TOP w0.127: Q14.3 LD1.1
N22816587: length 2.3
  TOP w0.127: R818.1 68.86,131.65 68.8,131.71 Q14.1
N22822538: length 1.8
  TOP w0.127: C742.1 R853.1
N22894279: length 3.1
  TOP w0.127: U115.7 296.17,55.69 296.17,55.69 v2(296.65,55.69)
  BOTTOM w0.127: v2(296.65,55.69) 296.11,55.69 295.61,56.2 R827.1
N22896034: length 3
  TOP w0.127: R876.2 296.86,52.46 296.47,52.85 296.47,53.48 296.26,53.69 U115.3
N22896196: length 9.5
  TOP w0.127: R500.1 278.84,51.48 278.89,51.53 278.89,51.58 279.15,51.83 281.69,51.83 281.94,52.08 281.94,55.13 281.48,55.59 U69.4
N23280297: length 11
  TOP w0.127: R832.2 126.25,100.99 126.36,100.88 126.37,100.88 127.3,99.94 133.5,99.94 133.86,100.29 133.86,101.51 133.6,101.77 U122.5
N23290716: length 4
  TOP w0.127: v2(46.31,113.79) 45.66,113.79 45.54,113.92 U76.10
  BOTTOM w0.127: v2(46.31,113.79) 46.31,112.87 45.59,112.15 R747.1
N23290763: length 1.5
  TOP w0.127: R834.2 46.69,114.99 46.63,115.05 U76.1
N23291275: length 2.1
  TOP w0.127: v2(46.25,105.16) 46.25,105.25 46.03,105.47 U124.10
  BOTTOM w0.127: v2(46.25,105.16) 46.25,104.2 R835.1
N23291293: length 1.7
  TOP w0.127: R836.2 46.48,106.06 46.33,106.22 U124.1
N23455572: length 2.5
  TOP w0.127: U126.3 170.06,211.67 170.08,211.65 R839.2
N23499910: length 4.3
  TOP w0.127: R840.2 182.52,210.45 182.3,210.68 182.3,211.17 182.76,211.63 U125.3
N23499916: length 10
  TOP w0.127: R841.2 180.38,212.67 180.87,212.18 181.91,212.18 182.09,212.36 182.09,213.32 U125.2 182.11,215.69 180.77,217.03 180.77,218.15 180.58,218.34 R842.1
N23506369: length 5.1
  TOP w0.127: R843.1 194.56,211.42 194.35,211.63 U128.3 194.31,213.21 194.31,214.11 194.18,214.24 193.85,214.24 193.7,214.09 U128.2
N23623251: length 14.6
  TOP w0.127: U116.10 238,234.08 238.1,233.98 238.1,233.88 238.59,233.39 ; 238.05,233.39 236.93,233.39 v2(236.6,233.06) ; 238.05,233.39 238,233.44 237.49,233.44 237.35,233.58 U116.9 ; 238.05,233.39 238.59,233.39 ; 238.59,233.39 C743.2 ; C743.2 238.69,233.94 238.65,233.98 U116.11 ; C743.2 238.69,232.84 238.67,232.82 L9.1
  vias: v2(235.84,234.84) v2(235.97,233.69) v2(235.97,232.93) v2(235.97,231.79) v2(235.97,231.03) v2(236.47,234.84) v2(236.6,231.92) v2(236.6,231.15) v2(237.36,231.92) v2(237.36,231.03)
N23623286: length 2
  TOP w0.127: U116.12 239.3,234.48 239.99,233.79 C743.1
N23623990: length 2.1
  TOP w0.127: C741.1 239.09,240.35 238.65,239.91 U116.2
N23625135: length 2.1
  TOP w0.127: R853.2 237.57,240.35 238,239.91 U116.3
N23636920: length 4.1
  TOP w0.127: R838.1 168.87,215.7 169.41,215.16 U126.2
N23802356: length 5.8
  TOP w0.127: U132.7 220.85,86.77 R864.2 221.98,86.37 222.28,86.37 222.88,86.98 222.88,87.38 222.76,87.51 222.61,87.51 222.35,87.77 U132.10
N23802386: length 3.1
  TOP w0.127: U132.21 219.35,94.72 R866.2
N23802411: length 3
  TOP w0.127: U132.2 217.63,88.23 217.42,88.03 R865.1
N23851798: length 53.5
  TOP w0.127: U1.L22 v1(175.61,112.21)
  L03_SIG1 w0.127: v1(175.61,112.21) 176,111.82 179.94,111.82 180.85,110.91 181.38,110.91 181.61,111.14 181.61,113.17 181.36,113.42 181.05,113.42 181.04,113.43 180.97,113.43 180.59,113.81 180.59,114.7 180.91,115.01 181.42,115.01 181.61,114.82 181.61,114.44 181.84,114.21 182.6,114.21 183.26,113.55 185.93,113.55 186.31,113.17 186.31,111.49 187.5,110.3 194.64,110.3 197.1,107.84 197.1,103.46 201.93,98.63 209.23,98.63 v2(210.44,99.84)
  BOTTOM w0.127: v2(210.44,99.84) 209.46,99.84 R352.1
N23851802: length 54.7
  TOP w0.102: U1.M22 v1(174.81,111.41)
  TOP w0.127: v2(190.25,98.82) 190.75,98.82 191.31,99.38 196.06,99.38 199.29,102.61 209.4,102.61 v2(210.31,101.69)
  BOTTOM w0.127: v1(174.81,111.41) 175.22,111.82 175.84,111.82 176.05,112.03 176.05,112.82 176.02,112.85 176.02,114.05 176.17,114.21 176.68,114.21 176.8,114.33 176.8,114.77 177.06,115.02 177.37,115.02 177.6,115.25 177.6,115.26 177.62,115.27 177.62,115.58 177.86,115.82 179.74,115.82 179.75,115.81 179.77,115.81 180,115.58 180,115.56 180.33,115.23 180.33,114.48 180.34,114.47 180.34,111.65 184.28,107.71 184.28,102.87 186.93,100.22 188.85,100.22 v2(190.25,98.82) ; v2(210.31,101.69) 210.31,101.84 210.19,101.97 R350.1
N23881985: length 2.2
  BOTTOM w0.127: R697.1 224.84,81.23 U37.1
N23882833: length 3.9
  TOP w0.127: U134.15 229.36,110.53 229.67,110.23 229.67,109.08 229.97,108.78 R868.1
N23883268: length 2.1
  TOP w0.127: U59.5 191.04,138.57 191.4,138.94 R869.2
N23883344: length 2.8
  TOP w0.127: v2(234.29,92.22) 234.24,92.27 U133.15
  BOTTOM w0.127: R867.1 234.96,91.55 v2(234.29,92.22)
N23992168: length 4.3
  BOTTOM w0.127: R873.1 202.69,153.04 202.69,153.68 202.44,153.94 200.79,153.94 200.47,153.63 U136.7
N23992275: length 3.5
  TOP w0.127: SW15.1 223.87,153.3 223.78,153.38 R787.2
N23992339: length 2.3
  BOTTOM w0.127: U137.5 204.32,150.26 203.89,149.82 R874.2
N23995153: length 2.8
  TOP w0.127: U64.7 R812.1
N23995260: length 2.7
  TOP w0.127: v2(153.46,249) 153.38,248.92 SW11.1
  BOTTOM w0.127: v2(153.46,249) R748.2
N23995326: length 2.2
  TOP w0.127: U135.5 204.09,150.26 203.91,150.07 R870.2
N24555288: length 196
  TOP w0.127: v2(274.6,69.13) 274.52,69.2 263.68,69.2 258.39,74.49 v2(251.66,74.49) ; R875.1 286.67,61.35 v2(286.56,61.46) ; U1.AB24 166.81,109.81 v1(166.81,108.14)
  L03_SIG1 w0.127: v2(177.95,76.14) 182.17,76.14 183.36,74.94 198.75,74.94 207.21,66.49 207.21,65.7 212.19,60.72 222.2,60.72 229.31,67.83 229.31,77.97 230.48,79.14 241.63,79.14 245.06,75.71 245.06,74.46 245.64,73.88 246.71,73.88 248.67,75.83 250.32,75.83 v2(251.66,74.49)
  BOTTOM w0.127: v1(166.81,108.14) 166.8,108.14 165.91,108.14 164.34,106.56 164.34,104.89 163.47,104.03 163.47,102.3 161.9,100.73 160.67,100.73 160.16,100.22 160.16,99.21 159,98.06 159,83.07 167.72,74.36 175.69,74.36 177.47,76.14 v2(177.95,76.14) ; v2(274.6,69.13) 280.39,69.13 286.56,62.96 v2(286.56,61.46)
N24769033: length 2.4
  TOP w0.102: U17.N19 v2(249.26,48.85)
  BOTTOM w0.381: v2(249.26,48.85) 249.26,48.84 R880.1
N25011059: length 2.2
  TOP w0.127: U10.4 124.57,224.78 124.33,224.55 C793.1
N25715331: length 4.5
  TOP w0.127: R882.1 106.3,191.91 105.92,192.29 105.92,194.32 106.19,194.59 U138.6
N25716335: length 2.9
  TOP w0.127: R633.1 261.51,225.95 260.99,226.47 J46.1
N25806665: length 2.8
  TOP w0.127: R886.1 J45.1
N25806674: length 2.9
  TOP w0.127: R887.1 287.91,64.78
N26130204: length 2
  TOP w0.127: U141.12 286.19,196.04 286.48,195.76 C805.1
N26130308: length 3.5
  TOP w0.127: U141.2 285.54,203.8 C810.1
N26134731: length 2.5
  TOP w0.127: U141.3 284.89,202.48 R897.1
N26134738: length 1.9
  TOP w0.127: R897.2 282.39,204.42 C811.1
N26188507: length 7.8
  TOP w0.102: 68.83,195.14 69.47,195.14 69.85,195.52 70.64,195.52 U20.M2
  TOP w0.127: 68.83,195.14 67.18,195.14 66.12,194.07 64.77,194.07 TP68.1
N26212205: length 4.2
  TOP w0.127: 207.66,208.13 R903.1 ; 207.66,208.13 207.98,208.45 U142.8 ; 207.66,208.13 207.99,207.8 U142.9
N26212363: length 4
  TOP w0.127: U142.13 215.8,208.45 216.19,208.06 216.19,208.03 ; 216.19,208.03 215.96,207.8 U142.12 ; 216.19,208.03 216.4,207.82 R902.1
N26217961: length 8.2
  TOP w0.127: v1(175.76,187.38) 176.16,187.38 176.51,187.73 U29.M6
  BOTTOM w0.127: R681.2 176.65,192.11 176.14,191.6 176.14,187.76 v1(175.76,187.38)
N26217993: length 8.2
  TOP w0.127: U29.M5 177.01,187.61 v1(176.8,187.41)
  BOTTOM w0.127: v1(176.8,187.41) 176.52,187.69 176.52,190.96 178.43,192.87 R687.2
N26218848: length 7.6
  TOP w0.127: R267.2 v2(175.25,197.06) 175.76,196.55 175.76,194.26 175.62,194.12 R268.1
  BOTTOM w0.127: R267.2 v2(175.25,197.06) 175.25,195.55 R678.1
N26218884: length 9.5
  TOP w0.127: v1(177.48,186.69) 177.29,186.88 U29.K5
  L03_SIG1 w0.127: v1(177.48,186.69) 176.54,186.69 176.28,186.96 176.28,192.04 v2(175.13,193.18)
  BOTTOM w0.127: v2(175.13,193.18) 175.12,193.19 R678.2
N27235884: length 1.9
  TOP w0.127: C288.2 23.04,61.23 23.03,61.22 U74.16
N27236702: length 2.4
  TOP w0.127: U74.9 19.69,58.38 20.57,57.49 R504.2
N27263094: length 5.8
  TOP w0.127: U13.6 v2(24.81,231.33)
  BOTTOM w0.127: C394.1 24.49,227.35 24.49,231.01 v2(24.81,231.33)
N27263096: length 6.9
  TOP w0.127: v2(25.53,231.73) 25.53,230.7 25.46,230.63 U13.5
  BOTTOM w0.127: v2(25.53,231.73) 25.53,231.03 25.2,230.7 25.2,228.49 25.8,227.89 C394.2
N27263102: length 3.1
  TOP w0.127: U13.2 v2(27.41,231.28)
  BOTTOM w0.127: C391.1 27.32,230.43 27.41,230.52 v2(27.41,231.28)
N27263104: length 2.4
  TOP w0.127: U13.4 v2(26.11,230.95)
  BOTTOM w0.127: v2(26.11,230.95) 26.11,229.97 C391.2
N27263131: length 2.7
  TOP w0.127: C41.2 26.42,231.51 26.76,231.17 U13.3
N27263145: length 2.5
  TOP w0.127: U13.7 24.16,231.48 24.13,231.51 C40.2
N27263153: length 3
  TOP w0.127: U13.16 28.58,224.04 28.7,223.92 R135.2
N27263155: length 2.4
  TOP w0.127: U13.12 R134.2
N27270427: length 3.1
  TOP w0.127: R837.1 32.52,211.64 32.41,211.52 32.41,209.88 32.55,209.74 U129.10
N27270431: length 2.5
  TOP w0.127: R846.2 30.39,208.61 30.53,208.47 U129.1
N27271424: length 3.4
  TOP w0.127: U130.10 43.27,208.77 41.59,207.09 R847.1
N27271428: length 2.2
  TOP w0.127: R848.2 43.46,206.71 43.95,207.2 44.05,207.2 44.25,207.4 44.25,208.42
N27273273: length 3
  TOP w0.127: R849.1 21.59,91.19 21.62,91.21 U146.10
N27273277: length 2.8
  TOP w0.127: U146.1 22.89,89.45 22.61,89.17 R850.2
N27274474: length 3.1
  TOP w0.127: U147.10 33.75,91.43 33.8,91.39 R871.1
N27274478: length 2.9
  TOP w0.127: U147.1 35.71,92.7 35.94,92.47 R872.2
N27876508: length 1.1
  TOP w0.127: R926.2 v2(260.99,241.44)
  vias: v2(259.21,239.66) v2(259.21,238.77) v2(260.1,239.66) v2(260.1,238.77) v2(260.99,243.22) v2(260.99,242.33) v2(260.99,240.55) v2(260.99,239.66) v2(260.99,238.77) v2(261.87,243.22) v2(261.87,242.33) v2(261.87,241.44) v2(261.87,240.55) v2(261.87,239.66) v2(261.87,238.77) v2(262.76,243.22) v2(262.76,242.33) v2(262.76,241.44) v2(262.76,240.55) v2(262.76,239.66) v2(262.76,238.77) v2(263.65,243.22) v2(263.65,242.33) v2(263.65,241.44) v2(263.65,240.55) v2(263.65,239.66) v2(264.54,243.22) v2(264.54,242.33) v2(264.54,241.44) v2(264.54,240.55) v2(264.54,239.66) v2(265.43,240.55) v2(265.43,239.66)
N28004667: length 2
  BOTTOM w0.127: R917.2 276.99,211.04 277.5,211.56 U149.1
N28004936: length 1.8
  BOTTOM w0.127: U149.9 283.16,212.62 283.17,212.63 R892.2
N28004974: length 3.7
  BOTTOM w0.127: C826.1 281.67,215.91 280.8,215.04 280.8,213.81 280.99,213.62 U149.7
N28005348: length 2.2
  TOP w0.254: LD9.2 255.74,246.01 256.1,246.38 R30.2
N28027381: length 12
  TOP w0.254: Q19.3 249.3,236.23 252.99,239.92 LD14.1
N28029912: length 1.9
  TOP w0.254: v2(277.5,215.02) 277.5,215.01 R922.2
  BOTTOM w0.254: U149.5 v2(277.5,215.02)
N28030740: length 11
  TOP w0.254: R923.2 252.86,233.07 251.84,234.09 251.84,237.89 253.49,239.54 254.25,239.54 254.89,240.17 LD14.2
N28032220: length 9
  BOTTOM w0.127: R919.2 280.54,210.44 279.53,211.46 279.53,213.12 279.02,213.63 278.43,213.63 278.42,213.62 U149.4 276.59,213.62 276.22,213.99 276.22,215.31 276.13,215.41 R921.1
N28032223: length 6.5
  BOTTOM w0.127: R918.2 279.02,212.74 278.64,213.12 U149.3 276.09,213.12 275.45,213.76 R920.1
N28034077: length 21.5
  TOP w0.508: SW1.3 272.83,245.46 ; SW1.3 271.78,244.41 ; SW1.3 271.78,246.52 ; J3.1 285.55,237.12 ; J3.1 282.96,238.32 ; J3.1 282.96,235.93 ; J3.1 280.37,237.12
  BOTTOM w0.508: SW1.3 272.83,245.46 ; SW1.3 271.78,246.52 ; SW1.3 271.78,244.41 ; J3.1 282.96,238.32 ; J3.1 285.55,237.12 ; J3.1 280.37,237.12 ; J3.1 282.96,235.93
N28055806: length 1.6
  TOP w0.127: F2.1 261.22,247.64
  vias: v2(261.24,249.44) v2(261.24,248.55) v2(261.24,247.66) v2(262.13,249.44) v2(262.13,248.55) v2(262.13,247.66) v2(263.02,249.44) v2(263.02,248.55) v2(263.02,247.66) v2(263.91,249.44) v2(263.91,248.55) v2(263.91,247.66) v2(264.8,249.44) v2(264.8,248.55) v2(264.8,247.66) v2(265.68,249.44) v2(265.68,248.55) v2(265.68,247.66) v2(266.57,249.44) v2(266.57,248.55) v2(266.57,247.66) v2(267.46,249.44) v2(267.46,248.55) v2(267.46,247.66) v2(268.35,249.44) v2(268.35,248.55) v2(268.35,247.66)
N28098623: length 6
  TOP w0.127: R924.2 251.15,226.33 251.02,226.2 D18.1 250.35,226.65 250.32,226.68 250.32,227.09 250.19,227.22 248.54,227.22 248.35,227.41 Q19.1
N28173616: length 4
  TOP w0.381: D19.1 250.55,242.92 251.23,243.6 LD15.2
N28350475: length 4.5
  TOP w0.254: LD15.1 256.67,243.6 257,243.27 R926.1
N28489979: length 13.6
  TOP w0.127: R737.2 176.28,137.94 v1(176.78,137.43) 176.36,137.43 174.81,135.87 174.81,128.21 U1.L2
  BOTTOM w0.127: R927.1 177.55,137.77 177.2,137.43 v1(176.78,137.43)
N28490065: length 38.8
  TOP w0.127: TP143.1 181.79,151.58 182.12,151.25 182.12,150.13 v2(182.25,150) ; U1.G3 v1(178.01,127.41)
  L08_SIG2 w0.102: v1(178.01,127.41) 178.01,127.21 178.39,126.83 178.39,125.66 178.17,125.43 177.74,125.43 176.91,124.6 176.11,124.6 175.21,125.5 175.21,128.74 176.4,129.94 176.4,131.84
  L08_SIG2 w0.127: 176.4,131.84 177.16,132.6 177.16,133.87 180.14,136.84 180.14,139.88 180.99,140.73 180.99,143.49 179.86,144.62 179.86,149.48 180.02,149.65 180.02,149.81 180.53,150.32 181.93,150.32 v2(182.25,150)
N28490068: length 24.2
  TOP w0.102: U1.Y14 v1(167.61,117.81)
  BOTTOM w0.102: v1(167.61,117.81) 168.02,117.4 168.02,114.95 168.81,114.16 168.81,112.87 168.54,112.6 168.24,112.6 168,112.36 168,112 167.79,111.8 167.41,111.8 167.2,111.59 167.2,111.26 166.95,111.01 166.67,111.01 166.4,110.74 166.4,110.4 165.9,109.91 165.9,108.89 164.26,107.25 ; TP149.1 160.5,101.08 161.86,101.08 163.19,102.41 163.19,104.12
  BOTTOM w0.127: 164.26,107.25 164.07,107.06 164.07,105.01 163.19,104.12
N28490071: length 23.9
  TOP w0.102: U1.Y19 v1(167.61,113.81)
  BOTTOM w0.102: v1(167.61,113.81) 167.42,113.81 166.21,112.6 165.82,112.6 165.62,112.4 165.62,112.07 165.35,111.8 165,111.8 164.39,111.19 164.39,110.43 163.14,109.18 163.14,105.65 162.15,104.65 162.15,103.04 161.08,101.97 159.52,101.97 158.58,101.03 157.56,101.03 156.21,99.68 TP151.1
N28490074: length 28.3
  TOP w0.127: TP145.1 v2(195.96,101.87) ; U1.F18 v1(178.81,114.61)
  L08_SIG2 w0.102: 189.1,109.6 189.1,109.62 188.59,110.12 187.92,110.12 187.38,109.59 186.5,109.59 185.51,110.58 182.87,110.58 182.78,110.49 181.3,110.49 180.57,111.23 180.57,113.39 179.77,114.19 179.45,114.19 179.45,114.19 179.07,114.57 178.85,114.57 v1(178.81,114.61)
  L08_SIG2 w0.127: 189.1,109.6 189.68,109.03 189.69,109.03 189.71,109.01 191.67,109.01 193.47,107.2 194.93,107.2 195.96,106.18 v2(195.96,101.87)
N28490077: length 29.8
  TOP w0.127: TP141.1 180.14,153.2 179.58,152.64 179.58,150.89 v2(181.48,148.99) ; U1.H2 v1(177.21,128.21)
  L08_SIG2 w0.127: v1(177.21,129.88) 176.78,130.31 176.78,131.59 177.55,132.35 177.55,133.87 180.38,136.71 180.38,139.73 181.8,141.15 181.8,144.86 180.72,145.94 180.72,147.78 181.48,148.54 v2(181.48,148.99)
  BOTTOM w0.127: v1(177.21,128.21) v1(177.21,129.88)
N28490080: length 34.9
  TOP w0.102: U1.AA18 v1(166.81,114.61)
  BOTTOM w0.102: v1(166.81,114.61) 166.4,114.2 164.62,114.2 164.5,114.31 163.3,114.31 163.14,114.16 163.14,113.58 162.43,112.87 162.43,112.86 162.21,112.63 162.2,112.63 162.15,112.59 161.21,112.59 160.99,112.82 157.94,112.82 157.25,113.5 157.25,113.98 157,114.24 154.41,114.24 153.59,113.43 152.81,113.43 151.26,111.88 151.26,102.76 152.53,101.49 152.53,98.44 TP150.1
N28490154: length 35.2
  TOP w0.127: v2(187.12,151.35) 188.09,151.35 188.59,150.84 TP142.1 ; U1.D2 v1(181.21,128.21)
  L08_SIG2 w0.127: v2(187.12,151.35) 183.95,148.17 183.95,144.52 182.75,143.32 182.75,141.37 183.39,140.73 184.35,140.73 185.17,139.92 185.17,138.57 182.78,136.18 182.16,136.18 180.34,134.37 180.34,129.08 v1(181.21,128.21)
N196364310: length 16.1
  TOP w0.102: U32.B8 248.52,176.37 248.54,176.39
  TOP w0.127: TP89.1 258.7,184.93 252.81,179.03 252.69,179.03 251.19,179.03 248.54,176.39
N284049954: length 2.5
  TOP w0.127: R175.1 90.6,229.45 90.09,229.96 SW3.5
N284049955: length 2.4
  TOP w0.127: SW3.6 90.35,231.23 90.6,230.98 R183.1
N284049956: length 2.3
  TOP w0.127: SW3.7 R190.1
N284049957: length 2.4
  TOP w0.127: SW3.8 90.12,233.77 90.37,234.03 R197.1

## Copper pours and planes (outline as drawn)
AGND on TOP: 227.3,160.47 227.3,161.84 224.54,161.84 224.54,160.47
AGND on L07_GND3: 233.6,155.95 231.98,157.57 227.05,157.57 226.24,158.38 226.24,160.21 224.56,160.21 224.56,161.48 228.98,161.48 230.48,159.98 236.22,159.98 237.16,159.04 241.05,159.04 242.04,160.03 243.94,160.03 245.11,161.2 245.11,163.29 243.31,165.09 243.31,167.91 242.52,168.7 242.52,175.33 243.36,176.16 248.31,176.16 249.66,177.51 249.95,177.51 249.95,178.51 250.55,179.11 254.79,179.11 255.83,180.15 257.51,180.15 257.71,179.95 257.71,176.93 256.39,175.61 253.16,175.61 253.03,175.73 253.03,176.49 252.62,176.91 252.43,176.91 252.43,174.97 252.2,174.74 247.85,174.74 247.12,174 247.12,172.23 249.43,169.92 249.43,158.87 248.69,158.13 245.8,158.13 244.98,158.94 244.04,158.94 242.75,157.65 242.75,156.99 241.71,155.95
AGND_XTAL on TOP: 250.6,172.05 250.32,172.33 250.32,172.94 250.24,173.01 250.22,173.01 249.81,173.42 248.01,173.42 247.85,173.27 247.85,172.63 247.73,172.51 247.22,172.51 246.99,172.73 246.99,173.57 246.96,173.6 246.96,173.8 247.37,174.21 250.19,174.21 250.22,174.23 250.22,174.26 250.8,174.84 256.01,174.84 257.96,176.8 257.96,178.53 258.24,178.81 260.81,178.81 262.03,177.59 262.03,175.05 262.89,174.18 264.85,174.18 265.38,173.65 265.38,172.73 264.92,172.28 262.51,172.28 262.1,172.68 253.42,172.68 252.78,172.05 ; 2 cut-outs
AGND_XTAL on L02_GND1: 246.99,173.57 246.99,172.73 247.22,172.51 247.73,172.51 247.85,172.63 247.85,173.27 248.01,173.42 249.81,173.42 250.22,173.01 250.24,173.01 250.32,172.94 250.32,172.33 250.6,172.05 252.78,172.05 253.42,172.68 262.1,172.68 262.51,172.28 264.92,172.28 265.38,172.73 265.38,173.65 264.85,174.18 262.89,174.18 262.03,175.05 262.03,177.59 260.81,178.81 258.24,178.81 257.96,178.53 257.96,176.8 256.01,174.84 250.8,174.84 250.22,174.26 250.22,174.23 250.19,174.21 247.37,174.21 246.96,173.8 246.96,173.6
DGND on BOTTOM (solid shape): 193.62,92.67 193.73,92.69 193.79,92.6 193.79,85 193.23,84.43 193.12,84.41 193.05,84.51 193.05,92.11
DGND on BOTTOM (solid shape): 222.49,89.46 228.33,89.46 229.4,88.39 229.4,87.57 228.09,87.57 227.17,88.5 224.37,88.5 223.86,89 223.05,89 221.91,87.86 221.91,87.8 221.88,87.76 221.87,87.72 221.86,87.67 221.84,87.62 221.81,87.6 221.74,87.57 221.67,87.6 221.4,87.72 221.11,87.64 221.07,87.62 220.56,88.13 220.59,88.19 220.61,88.19 221.88,89.46 222.01,89.46 222.14,89.59 222.36,89.59
DGND on BOTTOM (solid shape): 179.45,89.22 179.54,89.19 180.8,87.93 180.8,85.91 180.76,85.83 180.67,85.81 180.41,85.8 180.2,85.65 180.15,85.63 180.1,85.62 180.06,85.61 180.02,85.59 179.4,85.59 179.34,85.65 179.31,85.76 179.41,85.83 179.5,85.83 179.5,88.45 179.29,88.45 179.29,88.99 179.34,89.07 179.38,89.15
DGND on BOTTOM (solid shape): outline of 99 points within 149.09,92.88 152.25,97.74
DGND on BOTTOM (solid shape): 153.05,65.85 153.45,65.67 153.85,65.85 154.25,65.67 154.65,65.85 154.73,65.82 154.76,65.79 154.79,65.71 154.76,65.64 154.62,65.37 154.67,65.08 154.67,64.52 154.83,64.37 154.83,64.07 154.68,63.92 154.62,63.72 154.59,63.65 154.52,63.62 153.19,63.62 153.12,63.65 153.09,63.72 153.08,63.8 153.05,63.89 153.05,63.95 153.1,63.95 153.1,65.06 153.1,65.06 153.1,65.31 153.06,65.49 152.95,65.64 152.92,65.71 152.95,65.79 152.98,65.82
DGND on BOTTOM (solid shape): 151.45,65.85 151.85,65.67 152.25,65.85 152.33,65.82 152.36,65.79 152.39,65.71 152.36,65.64 152.25,65.49 152.21,65.31 152.21,65.06 151.78,65.06 151.78,63.95 152.14,63.95 152.22,63.91 152.24,63.82 152.23,63.77 152.22,63.72 152.19,63.65 152.12,63.62 148.92,63.62 148.81,63.79 148.64,63.92 148.09,63.99 147.66,63.63 138.75,63.63 138.29,63.72 138.02,63.34 138.02,63.32 137.92,63.21 137.39,63.21 137.32,63.24 137.29,63.31 137.27,63.43 137.22,63.55 137.22,64.67 137.28,64.78 137.3,64.9 137.33,64.97 137.4,65 150.75,65 151.37,65.01 151.34,65.63 151.31,65.71 151.34,65.78 151.38,65.82
DGND on BOTTOM (solid shape): 178.73,98.5 178.73,95.09 178.52,94.89 178.52,94.51 178.44,94.51 178.44,93.53 177.46,93.53 177.46,93.45 177.33,93.45 176.82,92.94 176.82,91.91 178.84,89.9 178.86,89.8 178.8,89.73 178.5,89.41 178.6,88.99 178.6,88.45 178.38,88.45 178.38,86.7 178.29,86.7 178.02,86.97 178.02,89.27 176.14,91.15 176.14,94.12 176.2,94.21 176.31,94.19 178.11,94.58 176.95,96 176.86,96.04 176.84,96.14 176.86,96.24 176.86,96.34 176.88,96.38 176.91,96.43 176.92,96.46 176.94,96.51 177.03,96.6 177.14,96.62 177.2,96.53 177.2,96.51 177.56,96.16 177.62,96.09 177.7,96.05 177.75,96.04 177.8,96.02 178.48,95.98 178.45,96.66 178.42,96.72 178.44,96.79 178.51,97.02 178.46,97.25 178.46,97.35 178.54,97.4 178.54,98.55 178.68,98.55
DGND on BOTTOM (solid shape): outline of 219 points within 185.57,72.87 193.12,80.06
DGND on L03_SIG1 (solid shape): 171.23,145.15 171.34,145.18 171.4,145.08 171.4,143.97 170.85,143.42 170.85,140.43 170.71,140.28 170.65,140.34 170.65,144.58
DGND on L03_SIG1 (solid shape): 236.99,48.45 236.89,48.35 235.66,48.35 235.23,47.92 234.89,47.92 234.8,47.98 234.82,48.09 235.25,48.53 236.91,48.53
DGND on L03_SIG1 (solid shape): 292.72,59.48 292.79,59.57 292.9,59.55 293.57,58.87 293.57,56.84 294.58,55.84 294.58,55.19 293.85,54.46 293.54,54.78 293.54,56.3 292.72,57.11
DGND on L03_SIG1 (solid shape): 233.03,57.16 233.71,56.49 235,56.49 235.2,56.69 235.31,56.71 235.37,56.61 235.37,56.05 232.78,56.05 232.73,56.1 232.73,59.84 233.03,59.84
DGND on L03_SIG1 (solid shape): 65.39,180.55 65.48,180.48 65.46,180.37 62.52,177.43 62.41,177.41 62.35,177.51 62.35,177.65 65.25,180.55
DGND on L03_SIG1 (solid shape): 122.84,26.47 122.94,26.41 122.91,26.3 118.14,21.52 113,21.52 112.9,21.58 112.93,21.69 117.71,26.47
DGND on L03_SIG1 (solid shape): 135.1,97.89 135.12,97.78 135.03,97.72 133,97.72 132.46,98.25 132.44,98.36 132.53,98.43 134.56,98.43
DGND on L03_SIG1 (solid shape): 178.85,134.23 178.96,134.26 179.02,134.16 179.02,130.44 178.79,130.21 178.68,130.19 178.61,130.28 178.61,134
DGND on L03_SIG1 (solid shape): 265.46,93.7 273.48,93.7 273.65,93.54 273.65,93.25 273.65,93.24 273.66,93.19 273.61,93.16 265.83,93.16 255.16,103.83 255.14,103.88 255.19,103.91 255.24,103.91
DGND on L03_SIG1 (solid shape): 278.39,70.43 278.46,70.53 278.57,70.5 285.65,63.42 285.67,63.31 285.58,63.25 282.73,63.25 278.39,67.58
DGND on L03_SIG1 (solid shape): 292.93,103.82 293,103.92 293.11,103.9 293.4,103.6 293.4,97.9 293.34,97.81 293.23,97.83 292.93,98.13
DGND on L03_SIG1 (solid shape): 278.11,50.23 278.14,50.18 278.14,47.67 276.89,46.42 276.78,46.39 276.72,46.49 276.72,48.88 278.01,50.17 278.05,50.21
DGND on L03_SIG1 (solid shape): 101.89,40.31 101.98,40.25 101.96,40.14 101.49,39.66 101.49,36.11 101.26,35.88 101.15,35.86 101.09,35.95 101.09,39.87 101.52,40.31
DGND on L03_SIG1 (solid shape): 117.66,20.78 117.76,20.72 117.73,20.61 117.51,20.39 108.8,20.39 108.56,20.63 108.12,20.63 108.12,20.64 105.38,20.64 105.32,20.69 105.31,20.75 105.35,20.78
DGND on L03_SIG1 (solid shape): 192.13,87.1 192.54,87.1 192.54,86.27 192.48,86.17 192.37,86.2 190.42,88.14 190.34,88.21 190.37,88.31 190.55,88.5 190.73,88.5
DGND on L03_SIG1 (solid shape): 207.55,115.38 207.65,115.32 207.63,115.21 207.3,114.89 204.13,114.89 204.07,114.93 204,114.95 203.93,115.03 203.96,115.12 204.22,115.38
DGND on L03_SIG1 (solid shape): 151.08,109.01 151.17,108.94 151.15,108.83 150.65,108.33 145.21,108.33 145.14,108.36 145.11,108.43 145.1,108.54 145.06,108.63 145.04,108.67 145.38,109.01
DGND on L03_SIG1 (solid shape): 99.88,39.83 99.99,39.85 100.05,39.75 100.05,34.73 99.99,34.64 99.88,34.66 99.38,35.16 99.38,39.4 99.59,39.61 99.66,39.61
DGND on L03_SIG1 (solid shape): 187.1,122.61 188.72,122.61 188.88,122.45 188.9,122.34 188.81,122.28 185.45,122.28 185.25,122.47 185.23,122.58 185.32,122.65 185.71,122.65 185.73,122.66 187.04,122.66
DGND on L03_SIG1 (solid shape): 195.06,92.47 201.88,92.47 201.96,92.44 201.98,92.36 201.98,92.31 201.85,92.18 194.8,92.18 193.68,93.3 193.01,93.3 192.6,93.71 192.58,93.82 192.67,93.88 193.65,93.88
DGND on L03_SIG1 (solid shape): 206.98,134.9 220.68,134.9 220.79,134.78 220.82,134.67 220.72,134.61 204.97,134.61 203.76,135.82 202.72,135.82 202.61,135.92 202.59,136.03 202.68,136.1 205.79,136.1
DGND on L03_SIG1 (solid shape): 171.98,115.5 172.05,115.47 172.08,115.4 172.09,115.32 171.7,114.93 171.7,113.45 171.67,113.37 171.6,113.34 171.5,113.34 171.5,115.46 171.54,115.5
DGND on L03_SIG1 (solid shape): 103.78,39.65 103.88,39.59 103.85,39.48 103.34,38.96 103.34,35.93 102.13,34.72 102.13,32.52 102.07,32.43 101.96,32.45 101.79,32.62 101.79,34.97 102.5,35.69 102.5,39.22 102.89,39.61 102.98,39.61 103.02,39.65
DGND on L03_SIG1 (solid shape): 199.67,25.62 199.74,25.59 199.77,25.51 199.77,25.4 199.8,25.29 199.79,25.19 199.71,25.15 197.84,25.15 196.32,23.62 192.89,23.62 192.25,24.26 192.24,24.33 192.24,24.39 196.42,24.39 197.65,25.62
DGND on L03_SIG1 (solid shape): 104.89,43.81 104.97,43.84 105.05,43.79 105.11,43.72 105.18,43.67 105.23,43.59 105.2,43.51 104.55,42.86 104.55,42.61 103.48,41.53 101.83,41.53 101.73,41.59 101.75,41.7 102.5,42.45 103.53,42.45
DGND on L03_SIG1 (solid shape): 91.18,174.45 91.21,174.37 91.21,173 93.89,170.32 93.91,170.32 101.72,162.51 101.72,161.77 101.65,161.67 101.54,161.69 92.18,171.06 92.17,171.06 90.93,172.3 90.93,174.37 90.96,174.45 91.04,174.47 91.1,174.47
DGND on L03_SIG1 (solid shape): 205.02,147.66 205.13,147.68 205.19,147.59 205.19,147.51 204.66,146.98 204.66,141.32 204.38,141.03 204.36,141.03 204.08,140.85 203.99,140.53 203.99,140.48 203.88,140.48 203.73,140.62 203.73,145.52 203.32,145.94 203.34,146 203.36,146
DGND on L03_SIG1 (solid shape): 266.77,170.24 266.82,170.09 266.85,169.94 266.82,169.55 266.94,169.19 266.94,169.09 266.85,169.04 266.73,169.04 264.59,171.17 250.49,171.17 250.12,171.54 250.1,171.65 250.19,171.72 265.29,171.72
DGND on L03_SIG1 (solid shape): 246.64,150.76 246.73,150.7 246.71,150.59 245.87,149.76 245.87,148.36 245.83,148.32 245.73,148.29 245.66,148.36 245.61,148.48 245.54,148.57 244.25,149.86 242.38,149.86 242.28,149.93 242.31,150.04 243.03,150.76
DGND on L03_SIG1 (solid shape): 151.87,138.34 151.93,138.44 152.05,138.42 153.31,137.15 153.31,134.52 154.3,133.53 154.3,131.95 154.24,131.85 154.13,131.88 153.75,132.26 153.33,132.67 153.36,132.7 153.43,132.83 153.46,132.97 153.46,133.55 152.88,134.13 152.12,134.13 151.99,134 151.87,134.12
DGND on L03_SIG1 (solid shape): 182.61,135.1 182.59,135.03 182.57,134.99 182.56,134.94 182.56,134.87 180.49,132.81 180.49,130.14 180.3,129.94 180.19,129.92 180.12,130.02 180.12,132.89 181.53,134.29 181.61,134.3 181.68,134.33 181.96,134.46 182.13,134.73 182.14,134.74 182.55,135.16
DGND on L03_SIG1 (solid shape): 274.77,95.65 274.79,95.54 274.7,95.48 273.84,95.48 272.9,96.42 272.4,96.42 272.31,96.47 272.31,96.57 272.36,96.83 272.27,97.07 272.26,97.18 272.35,97.23 273.19,97.23
DGND on L03_SIG1 (solid shape): 158.68,100.23 158.77,100.17 158.75,100.06 157.06,98.37 157.06,92.35 156.96,92.25 156.87,92.22 156.8,92.28 156.76,92.34 156.71,92.4 156.69,92.47 156.71,92.54 156.84,92.9 156.65,93.23 156.65,98.91 157.97,100.23
DGND on L03_SIG1 (solid shape): 139.78,128.52 139.82,128.44 139.82,118.57 139.73,118.48 139.69,118.52 139.68,118.53 139.48,118.76 139.19,118.8 139.1,118.82 139.07,118.89 139.07,120.11 139.56,120.6 139.56,128.2 139.4,128.36 139.4,128.4 139.43,128.48 139.51,128.51 139.6,128.51 139.69,128.53
