# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A14: length 134.8
  TOP w0.102: v1(131.35,115.71) 132.69,115.71 132.87,115.89 U52.N7 ; U49.N7 132.87,131.13 132.69,130.95 v1(131.35,130.95) ; R308.1 128.44,172.35 129.92,173.83 129.92,175.65 130.94,176.67 v1(131.35,176.67) 132.69,176.67 132.87,176.85 U27.N7 ; v1(131.35,146.19) 132.69,146.19 132.87,146.37 U45.N7 ; v1(131.35,161.43) 132.69,161.43 132.87,161.61 U39.N7 ; U1.Y17 v1(167.61,115.41)
  L03_SIG1 w0.102: v1(131.35,176.67) 130.45,176.67 130.3,176.52 130.3,167.3 131.85,165.75 131.85,164.33 131.35,163.82 v1(131.35,161.43) 130.71,161.43 130.58,161.31 130.58,151.83 131.88,150.54 131.88,149.52 131.35,148.99 v1(131.35,146.19) 130.76,146.19 130.53,145.96 130.53,141.54 130.43,141.44 130.23,141.44 130.12,141.34 130.12,141.14 130.23,141.04 130.43,141.04 130.53,140.93 130.53,136.53 131.83,135.24 131.83,134.58 131.84,134.56 131.84,133.89 131.35,133.39 v1(131.35,130.95) 130.84,130.44 130.84,125.25 130.66,125.07 130.66,124.84 130.84,124.66 130.84,124.44 130.66,124.26 130.66,124.03 130.84,123.85 130.84,123.62 130.66,123.45 130.66,123.22 130.84,123.04 130.84,120.95 131.95,119.83 131.95,118.99 131.55,118.58 131.55,117.59 131.35,117.39 v1(131.35,115.71) 131.35,115.31 131.24,115.2 131.24,111.25 133.74,108.75 143.64,108.75 145.01,110.12 147.69,110.12 147.84,109.97 148.1,109.97 148.25,110.12 148.51,110.12 148.66,109.97 148.91,109.97 149.06,110.12 149.32,110.12 149.47,109.97 149.72,109.97 149.88,110.12 150.55,110.12 150.65,110.23 150.65,110.94 150.76,111.04 150.96,111.04 151.06,110.94 151.06,110.12 151.16,110.02 151.39,110.02 151.49,110.12 151.49,110.94 151.59,111.04 151.8,111.04 151.9,110.94 151.9,110.23 152,110.12 152.23,110.12 152.38,109.97 152.64,109.97 152.79,110.12 153.04,110.12 153.19,109.97 153.45,109.97 153.6,110.12 153.86,110.12 154.01,109.97 154.26,109.97 154.41,110.12 154.67,110.12 154.82,109.97 155.07,109.97 155.23,110.12 155.35,110.12 156.62,111.39 157.78,111.39 158.29,111.9 160.12,111.9 160.87,112.65 161.29,112.65 161.36,112.59 162.32,112.59 162.71,112.98 163.46,112.98 164.01,113.53 164.01,114.19 164.82,115 167.2,115 v1(167.61,115.41)
DDR_A15: length 132.7
  TOP w0.102: U1.Y16 v1(167.61,116.21) ; U49.J7 v1(136.06,130.74) ; v1(136.05,176.46) 136.44,176.85 U27.J7 ; v1(136.05,161.22) 136.44,161.61 U39.J7 ; U45.J7 136.44,146.37 v1(136.05,145.98) ; v1(136.05,115.5) 136.44,115.89 U52.J7 ; R213.1 v2(135.64,185.94)
  L03_SIG1 w0.102: v1(136.05,176.46) 135.52,176.98 135.52,180.97 136.05,181.5 136.05,183.88 135.64,184.29 v2(135.64,185.94)
  L08_SIG2 w0.102: v1(136.05,115.5) 136.05,115.93 135.76,116.21 135.76,118.49 136.54,119.26 136.54,121.16 135.64,122.06 135.64,125.42 135.53,125.53 135.48,125.53 135.38,125.63 135.38,125.83 135.48,125.93 135.53,125.93 135.64,126.03 135.64,128.13 136.27,128.77 136.27,129.63 136.06,129.85 v1(136.06,130.74) 135.64,131.16 135.64,133.64 136.88,134.89 136.88,137.58 136.65,137.81 136.65,142.96 136.83,143.13 136.83,143.88 136.71,143.99 136.58,143.99 136.47,144.1 136.47,144.4 136.58,144.5 136.71,144.5 136.82,144.6 136.82,145.21 v1(136.05,145.98) 136.05,146.38 135.91,146.52 135.91,148.78 136.88,149.75 136.88,152.95 136.45,153.38 136.45,157.01 136.77,157.33 136.77,158.24 136.93,158.4 136.93,159.2 136.83,159.31 136.5,159.31 136.4,159.41 136.4,159.71 136.5,159.81 136.83,159.81 136.93,159.91 136.93,160.33 v1(136.05,161.22) 135.92,161.34 135.92,162.28 136.02,162.39 136.25,162.39 136.35,162.49 136.35,162.79 136.25,162.89 136.02,162.89 135.91,163.01 135.91,163.78 135.94,163.82 135.94,164.39 136.86,165.31 136.86,175.64 v1(136.05,176.46)
  BOTTOM w0.102: v1(167.61,116.21) 167.22,116.6 164.24,116.6 163.47,115.83 161.31,115.83 161.3,115.84 154.17,115.84 152.76,115.84 152.66,115.74 152.66,114.98 152.56,114.87 152.36,114.87 152.26,114.98 152.26,115.74 152.15,115.84 151.78,115.84 151.67,115.74 151.67,114.79 151.57,114.69 151.37,114.69 151.27,114.79 151.27,115.74 151.17,115.84 150.93,115.84 150.79,115.71 150.79,115.4 150.79,114.98 150.79,114.98 150.79,114.68 150.69,114.58 150.4,114.58 149.86,114.58 149.76,114.48 149.76,114.18 149.86,114.07 150.69,114.07 150.79,113.97 150.79,113.56 150.2,112.97 150.06,112.97 149.67,113.35 149.53,113.35 149.39,113.21 149.39,113.06 149.77,112.68 149.77,112.54 149.13,111.9 148.87,111.9 148.79,111.98 148.79,113.78 148.69,113.88 148.49,113.88 148.38,113.78 148.38,112.03 148.26,111.9 147.93,111.9 147.83,112 147.83,112.97 147.73,113.07 147.53,113.07 147.42,112.97 147.42,112 147.32,111.9 140.65,111.9 140.03,112.52 140.03,114.49 139.8,114.72 138.3,114.72 137.87,114.29 136.78,114.29 136.05,115.02 v1(136.05,115.5)
DDR_BA0: length 128.9
  TOP w0.102: v1(136.05,165.21) 136.05,165.23 136.43,165.61 136.43,165.61 U39.J2 ; U45.J2 136.05,149.97 v1(136.05,149.97) ; U1.AA14 v1(166.81,117.81) ; R212.1 134.11,185.21 136.05,183.28 136.05,180.47 ; v1(136.05,119.49) 136.44,119.89 U52.J2 ; 136.05,180.47 136.43,180.85 136.43,180.85 U27.J2 ; 136.05,180.47 v1(136.05,180.45) ; U49.J2 136.44,135.13 v1(136.05,134.73)
  L03_SIG1 w0.102: v1(166.81,117.81) 166.43,118.19 165.04,118.19 164.52,117.67 164.52,116.99 163.71,116.18 162.62,116.18 162.21,116.59 161.1,116.59 160.81,116.88 159.78,116.88 158.98,116.07 149.72,116.07 148.16,117.63 148.16,118.73 147.4,119.49 146.4,119.49 146.09,119.18 146.09,119.07 146.87,118.29 146.87,118.15 146.72,118.01 146.58,118.01 145.83,118.75 145.66,118.75 145.52,118.61 145.52,118.47 145.63,118.35 145.63,118.21 145.49,118.07 145.34,118.07 145.23,118.18 145.09,118.18 142.06,115.15 142.06,114.92 142.16,114.82 142.67,114.82 142.77,114.72 142.77,114.52 142.67,114.42 142.16,114.42 142.06,114.31 142.06,112.7 141.81,112.45 141.26,112.45 141.16,112.55 141.16,112.66 141.06,112.77 140.86,112.77 140.76,112.66 140.76,112.55 140.66,112.45 137.89,112.45 136.52,113.81 136.52,115.66 135.92,116.27 135.92,116.92 136.02,117.02 136.68,117.02 136.78,117.12 136.78,117.33 136.68,117.43 136.02,117.43 135.91,117.54 135.91,118.06 135.92,118.07 135.92,118.95 136.05,119.09 v1(136.05,119.49) 136.05,120.32 136.88,121.15 136.88,122.06 136.8,122.13 136.8,126.85 136.93,126.98 136.93,128.59 136.52,129 136.52,130.85 135.59,131.79 135.59,133.86 136.05,134.33 v1(136.05,134.73) 136.05,135.66 136.15,135.76 136.47,135.76 136.58,135.86 136.58,136.17 136.47,136.27 136.15,136.27 136.05,136.37 136.05,144.95 136.43,145.33 136.43,146.24 135.76,146.9 135.76,148.46 135.66,148.56 135.48,148.56 135.38,148.66 135.38,148.97 135.48,149.07 135.66,149.07 135.76,149.17 135.76,149.69 v1(136.05,149.97) 136.05,160.4 135.64,160.81 135.64,161.81 135.48,161.96 135.48,162.46 135.59,162.56 135.94,162.56 136.04,162.66 136.04,162.97 135.94,163.07 135.59,163.07 135.48,163.17 135.48,164.65 v1(136.05,165.21) 136.05,166.87 136.08,166.9 136.08,171.46 136.18,171.56 136.42,171.56 136.52,171.66 136.52,171.97 136.42,172.07 136.18,172.07 136.08,172.17 136.08,172.48 136.18,172.58 136.42,172.58 136.52,172.68 136.52,172.98 136.42,173.09 136.18,173.09 136.07,173.2 136.07,174.31 136.43,174.67 136.43,176.72 135.76,177.38 135.76,180.17 v1(136.05,180.45)
DDR_BA1: length 134.1
  TOP w0.102: U39.K8 135.65,160.82 135.64,160.82 v1(135.24,161.22) ; U27.K8 135.65,176.06 135.64,176.06 135.24,176.46 v1(135.24,176.46) ; v1(135.24,115.49) 135.64,115.09 U52.K8 ; U45.K8 135.65,145.58 135.64,145.58 135.24,145.98 v1(135.24,145.98) ; R214.1 v2(131.06,185.94) ; U1.AB13 v1(166.01,118.61) ; U49.K8 v1(135.24,130.74)
  L03_SIG1 w0.102: v1(135.24,176.46) 135.24,180.62 131.06,184.8 v2(131.06,185.94)
  L08_SIG2 w0.102: v1(135.24,115.49) 135.24,119.58 134.46,120.36 134.46,127.31 135.18,128.03 135.18,128.81 135.08,128.91 134.82,128.91 134.72,129.01 134.72,129.31 134.82,129.42 135.08,129.42 135.18,129.52 135.18,130.27 135.24,130.33 v1(135.24,130.74) 135.24,134.65 136.03,135.44 136.03,135.9 136.14,136 136.52,136 136.63,136.11 136.63,136.41 136.52,136.51 136.14,136.51 136.03,136.62 136.03,136.7 135.97,136.76 135.97,143.93 136.05,144.01 136.05,145.17 v1(135.24,145.98) 135.62,146.35 135.62,150.28 136.07,150.73 136.07,152.62 135.76,152.92 135.76,156.07 135.86,156.18 135.89,156.18 135.99,156.28 135.99,156.48 135.89,156.58 135.86,156.58 135.76,156.68 135.76,157.6 135.86,157.7 136.11,157.7 136.21,157.8 136.21,158.11 136.11,158.21 135.86,158.21 135.66,158.41 135.66,158.84 136.09,159.27 136.09,160.37 v1(135.24,161.22) 135.24,163.17 135.46,163.39 135.46,165.36 136.03,165.94 136.03,166.44 136.14,166.54 136.35,166.54 136.45,166.64 136.45,166.94 136.35,167.05 136.14,167.05 136.03,167.15 136.05,167.16 136.05,174.57 136.19,174.71 136.32,174.71 136.42,174.81 136.42,175.12 136.32,175.22 136.14,175.22 136.03,175.32 136.03,175.67 v1(135.24,176.46)
  BOTTOM w0.102: v1(135.24,115.49) 135.24,117.02 135.36,117.13 135.76,117.13 135.92,116.98 135.92,116.17 137.01,115.08 140,115.08 140.33,114.75 140.33,113.17 141.1,112.41 143.91,112.41 144.01,112.51 144.01,112.64 144.12,112.74 144.32,112.74 144.42,112.64 144.42,112.51 144.52,112.41 145.39,112.41 145.54,112.56 145.54,112.84 145.31,113.07 145.31,113.28 145.53,113.5 145.68,113.5 146.38,112.79 146.53,112.79 146.74,113.01 146.74,113.15 146.03,113.86 146.03,114.01 146.25,114.22 146.39,114.22 147.1,113.51 147.25,113.51 147.46,113.73 147.46,113.87 146.75,114.58 146.75,114.72 146.97,114.94 147.11,114.94 147.82,114.23 147.97,114.23 148.18,114.45 148.18,114.59 147.47,115.3 147.47,115.44 147.69,115.66 147.83,115.66 148.54,114.95 148.68,114.95 148.9,115.16 148.9,115.31 148.19,116.02 148.19,116.16 148.38,116.35 149.68,116.35 149.78,116.25 149.78,115.19 149.88,115.09 150.18,115.09 150.29,115.19 150.29,116.25 150.39,116.35 153.96,116.35 154.8,116.35 154.8,116.35 159.97,116.35 160.22,116.6 162.41,116.6 162.53,116.47 163.5,116.47 164.44,117.41 165.42,117.41 165.61,117.6 165.61,118.21 v1(166.01,118.61)
DDR_BA2: length 134.1
  TOP w0.102: U49.J3 136.45,133.93 136.29,133.77 v1(136.29,133.15) ; U52.J3 136.45,118.69 136.29,118.53 v1(136.29,117.91) ; v1(136.29,148.39) 136.29,149.01 136.45,149.17 U45.J3 ; U27.J3 136.45,179.9 136.45,179.65 136.29,179.49 v1(136.29,178.87) ; v1(136.29,163.63) 136.29,164.25 136.45,164.41 136.45,164.66 U39.J3 ; R211.1 v2(140.21,185.94)
  TOP w0.127: U1.AD17 164.41,115.41 v1(162.74,115.41)
  L03_SIG1 w0.102: v1(136.29,117.91) 136.29,118.78 137.15,119.64 137.15,120.76 137.54,121.15 137.54,123.76 137.74,123.96 137.74,124.17 137.54,124.37 137.54,128.44 136.75,129.22 136.75,131.05 135.94,131.87 135.94,132.8 v1(136.29,133.15) 136.29,133.94 136.85,134.5 136.85,134.85 136.75,134.95 136.52,134.95 136.42,135.06 136.42,135.36 136.52,135.46 136.75,135.46 136.86,135.58 136.86,138.19 136.68,138.37 136.68,142.46 136.93,142.71 136.93,144.49 136.68,144.74 136.68,146.42 136.29,146.81 136.29,147.14 136.39,147.24 136.58,147.24 136.68,147.34 136.68,147.64 136.58,147.75 136.39,147.75 136.29,147.85 v1(136.29,148.39) 136.29,149.38 136.68,149.77 136.68,151.66 136.86,151.84 136.86,153.17 136.68,153.35 136.68,156.32 136.78,156.42 137.19,156.42 137.29,156.52 137.29,156.83 137.19,156.93 136.78,156.93 136.68,157.03 136.68,157.83 136.83,157.98 136.83,159.98 136.45,160.37 136.45,161.86 136.29,162.02 v1(136.29,163.63) 136.29,164.42 136.52,164.65 136.52,166.74 137.06,167.27 137.06,168.95 136.96,169.05 136.73,169.05 136.63,169.15 136.63,169.46 136.73,169.56 136.96,169.56 137.06,169.66 137.06,169.96 136.96,170.07 136.73,170.07 136.63,170.17 136.63,170.47 136.73,170.57 136.96,170.57 137.06,170.68 137.06,174.05 136.7,174.41 136.7,176.85 136.29,177.26 v1(136.29,178.87)
  L08_SIG2 w0.102: v1(136.29,178.87) 136.29,179.59 136.47,179.78 136.47,181.68 140.21,185.42 v2(140.21,185.94) ; v1(162.74,115.41) 162.74,116.35 162.08,117 161.16,117 160.71,116.55 159.8,116.55 159.55,116.8 158.55,116.8 158.19,116.45 155.73,116.45 155.64,116.54 155.64,117.35 155.55,117.44 155.37,117.44 155.28,117.35 155.28,115.95 155.19,115.86 155.02,115.86 154.93,115.95 154.93,115.99 154.82,116.09 149.99,116.09 147.12,113.22 145.77,113.22 145.72,113.17 144.3,113.17 144.11,113.36 144.11,113.86 144.01,113.96 143.76,113.96 143.66,114.06 143.66,114.26 143.76,114.36 144.01,114.36 144.11,114.46 144.11,115.79 144.01,115.89 143.78,115.89 143.68,115.99 143.68,116.75 143.58,116.85 143.37,116.85 143.27,116.75 143.27,115.99 143.17,115.89 142.97,115.89 142.87,115.99 142.87,116.75 142.76,116.85 142.56,116.85 142.46,116.75 142.46,115.99 142.36,115.89 141.93,115.89 141.83,115.79 141.83,115.56 141.93,115.46 142.93,115.46 143.03,115.36 143.03,115.15 142.93,115.05 141.93,115.05 141.83,114.95 141.83,114.19 141.73,114.09 141.52,114.09 141.42,114.19 141.42,115.79 141.32,115.89 137.4,115.89 137.3,115.99 137.3,116.22 137.2,116.32 137,116.32 136.9,116.22 136.9,115.99 136.8,115.89 136.5,115.89 136.29,116.1 136.29,116.63 136.39,116.73 137.26,116.73 137.36,116.83 137.36,117.04 137.26,117.14 136.39,117.14 136.29,117.24 v1(136.29,117.91)
DDR_CAS#: length 133.6
  TOP w0.102: U52.G3 138.06,119.08 138.06,118.32 v1(138.23,118.15) ; v1(138.23,133.39) 138.06,133.56 138.06,134.32 U49.G3 ; U45.G3 138.06,149.56 138.06,148.8 v1(138.23,148.63) ; v1(138.23,179.11) 138.06,179.28 138.06,179.97 138.05,179.98 138.05,179.99 U27.G3 ; R207.1 v2(143.26,185.94) ; U39.G3 138.05,164.75 138.05,164.74 138.06,164.73 138.06,164.04 v1(138.23,163.87) ; U1.AC13 v1(165.21,118.61)
  L03_SIG1 w0.102: v2(143.26,185.94) 139.27,181.96 139.27,181.32 138.23,180.28 v1(138.23,179.11)
  L08_SIG2 w0.102: v1(165.21,118.61) 164.8,118.61 164.66,118.76 161.95,118.76 161.77,118.94 161.26,118.94 161.16,118.84 161.16,118.28 161.05,118.18 160.85,118.18 160.75,118.28 160.75,118.33 160.65,118.43 155.88,118.43 155.63,118.68 155.16,118.68 155.14,118.66 154.99,118.66 154.85,118.8 154.85,118.95 155.02,119.12 155.02,119.29 154.81,119.5 151.25,119.5 150.75,119 150.75,117.24 150.5,116.98 149.61,116.98 148.22,115.6 148.13,115.6 147.61,116.12 147.47,116.12 147.33,115.97 147.33,115.83 147.79,115.36 147.79,115.17 147.65,115.03 147.51,115.03 146.58,115.95 146.44,115.95 146.3,115.8 146.3,115.66 147.22,114.74 147.22,114.59 146.96,114.34 146.2,114.34 145.92,114.62 145.92,115.99 145.36,116.55 145.36,117.08 144.47,117.97 144.47,118.18 144.37,118.28 144.14,118.28 144.04,118.18 144.04,117.74 143.93,117.64 143.73,117.64 143.63,117.74 143.63,119.19 143.53,119.29 143.32,119.29 143.22,119.19 143.22,117.74 143.12,117.64 142.92,117.64 142.82,117.74 142.82,118.15 142.71,118.25 142.16,118.25 142.06,118.15 142.06,117.44 141.96,117.34 141.76,117.34 141.66,117.44 141.66,118.15 141.55,118.25 140.46,118.25 139.98,117.77 139.98,117.16 139.85,117.03 139.7,117.03 139.62,117.11 139.62,117.72 139.5,117.85 139.37,117.85 139.27,117.74 139.27,117.01 139.17,116.91 138.97,116.91 138.87,117.01 138.87,117.74 138.77,117.85 138.63,117.85 138.53,117.74 138.53,117.01 138.48,116.96 138.2,116.96 138.05,117.11 138.05,117.54 138.23,117.72 v1(138.23,118.15) 138.56,118.48 138.56,120.41 139.27,121.12 139.27,125.13 139.37,125.23 139.45,125.23 139.55,125.33 139.55,125.54 139.45,125.64 139.37,125.64 139.27,125.74 139.27,127.22 138.46,128.03 138.46,130.27 138.86,130.67 138.86,132.76 v1(138.23,133.39) 138.52,133.68 138.52,134.7 139.14,135.32 139.14,138.02 139.09,138.07 139.09,140.44 138.99,140.54 138.68,140.54 138.58,140.64 138.58,140.94 138.68,141.05 138.99,141.05 139.09,141.15 139.09,142.89 138.46,143.52 138.46,145.61 138.02,146.04 138.02,147.26 138.23,147.47 v1(138.23,148.63) 138.54,148.94 138.54,151.07 139.14,151.68 139.14,157.85 138.52,158.47 138.52,159.97 139.65,161.1 139.65,162.45 v1(138.23,163.87) 138.59,164.23 138.59,166.57 139.42,167.4 139.42,171.34 139.32,171.45 139.04,171.45 138.94,171.55 138.94,171.85 139.04,171.95 139.32,171.95 139.42,172.05 139.42,172.94 138.43,173.93 138.43,175.5 138.84,175.91 138.84,178.51 v1(138.23,179.11)
DDR_CB00: length 28.7
  TOP w0.102: U52.B3 142.43,119.47 143.84,119.47 145.65,121.28 146.45,121.28 146.56,121.38 146.56,121.65 146.66,121.75 146.86,121.75 146.96,121.65 146.96,121.38 147.06,121.28 147.27,121.28 147.37,121.38 147.37,121.55 147.47,121.65 147.67,121.65 147.78,121.55 147.78,121.38 147.88,121.28 156.58,121.28 v2(156.82,121.05)
  TOP w0.127: U1.AA11 v1(166.81,121.01)
  L08_SIG2 w0.102: v2(156.82,121.05) 157.02,121.25 160.69,121.25 161.03,121.59 161.03,121.93 161.32,122.21 163.64,122.21 164.16,121.69 164.4,121.69 164.59,121.5 165.28,121.5 165.77,121.01 v1(166.81,121.01)
DDR_CB01: length 28.6
  TOP w0.102: v1(157.94,119.42) 156.44,119.42 155.78,120.08 149.29,120.08 149.19,119.98 149.19,119.68 149.09,119.58 148.89,119.58 148.78,119.68 148.78,119.98 148.68,120.08 148.13,120.08 145.41,117.36 142.72,117.36 U52.C7
  TOP w0.127: U1.AB11 v1(166.01,120.21)
  L08_SIG2 w0.102: v1(157.94,119.42) 158.3,119.42 158.33,119.45 158.65,119.45 159.08,119.88 164.39,119.88 164.64,119.62 165.42,119.62 v1(166.01,120.21)
DDR_CB02: length 28.8
  TOP w0.102: U52.C2 v1(141.65,120.29)
  TOP w0.127: U1.AC11 v1(165.21,121.01)
  L08_SIG2 w0.102: v1(165.21,121.01) 164.8,121.01 164.8,121.02 163.85,121.02 163.48,121.39 161.89,121.39 161.4,120.89 157.91,120.89 157.61,120.59 155.98,120.59 155.47,121.1 146.06,121.1 145.65,121.5 145.65,122.09 145.55,122.19 145.35,122.19 145.25,122.09 145.25,121.5 145.14,121.4 144.68,121.4 143.79,122.29 142.34,122.29 142.06,122.01 142.06,120.7 v1(141.65,120.29)
DDR_CB03: length 28.6
  TOP w0.102: U52.C8 141.67,115.51 143.79,115.51 144.12,115.18 146.1,115.18 v1(149.43,118.51)
  TOP w0.127: U1.AC12 v1(165.21,120.21)
  L08_SIG2 w0.102: v1(149.43,118.51) 149.28,118.35 149.12,118.35 149.07,118.4 149.07,119.22 150.22,120.36 155.22,120.36 155.65,119.93 158.6,119.93 158.88,120.21 v1(165.21,120.21)
DDR_CBDQM: length 28.6
  TOP w0.102: v1(148.27,119.38) 147.98,119.09 147.98,119.04 145.92,116.98 143.14,116.98 U52.B7
  TOP w0.127: U1.Y11 v1(167.61,120.21)
  L08_SIG2 w0.102: v1(167.61,120.21) 167.21,120.61 162.83,120.61 162.79,120.58 158.03,120.58 157.73,120.28 155.75,120.28 155.35,120.69 149.57,120.69 v1(148.27,119.38)
DDR_CBDQS: length 28.6
  TOP w0.102: U52.C3 141.05,118.89 141.05,118.75 141.5,118.3 143.47,118.3 143.57,118.4 143.57,119.09 143.67,119.19 143.88,119.19 143.98,119.09 143.98,118.4 144.08,118.3 145.35,118.3 145.56,118.51 145.56,119.03 145.1,119.49 145.1,119.92 145.45,120.27 145.88,120.27 146.52,119.64 146.69,119.64 147.94,120.89 156.24,120.89 156.8,120.33 163.49,120.33 U1.AE12
DDR_CBDQS#: length 28.7
  TOP w0.102: U1.AD12 164.42,119.42 163.86,119.42 163.28,120 156.66,120 156.1,120.56 148.07,120.56 146.82,119.3 146.38,119.3 145.75,119.94 145.59,119.94 145.43,119.78 145.43,119.62 145.89,119.17 145.89,118.37 145.48,117.97 141.36,117.97 140.72,118.61 140.72,118.82 U52.D3
DDR_CE1Z: length 16.4
  TOP w0.102: U1.AB12 v1(166.01,119.41) ; TP155.1 151.38,118.76 v2(152.15,118.76)
  L03_SIG1 w0.102: v1(166.01,119.41) 165.86,119.27 164.39,119.27 163.97,118.85 162.51,118.85 162.34,119.02 159.29,119.02 158.32,118.05 157.37,118.05 157.01,118.4 155.53,118.4 155.5,118.43 154.75,118.43 154.72,118.4 153.95,118.4 153.59,118.76 v2(152.15,118.76)
DDR_CK: length 135.7
  TOP w0.102: U39.F7 139.18,161.61 139.25,161.68 v1(139.25,162.01) ; v1(139.25,146.77) 139.25,146.66 138.96,146.37 U45.F7 ; U49.F7 v1(139.25,131.53) ; U27.F7 139.19,176.85 139.25,176.91 v1(139.25,177.25) ; R216.1 149.39,180.56 148.77,181.18 146.5,181.18 v2(146.14,180.81) ; U52.F7 v1(139.25,116.29)
  TOP w0.127: v1(162.74,117.01) 163.14,117.41 U1.AE15
  L03_SIG1 w0.102: v1(162.74,117.01) 163.13,116.63 163.47,116.63 163.7,116.85 163.7,117.91 163.15,118.46 160.95,118.46 160.67,118.18 159.63,118.18 158.84,117.4 155.75,117.4 155.6,117.54 155.6,117.79 155.35,118.05 154.91,118.05 154.64,117.77 154.64,117.52 154.53,117.41 153.64,117.41 153.54,117.52 153.54,118.1 153.26,118.38 152.83,118.38 152.83,118.35 152.58,118.1 152.58,117.52 152.55,117.52 152.45,117.41 152.15,117.41 152.02,117.54 152.02,117.97 151.76,118.23 151.33,118.23 151.05,117.95 151.05,117.52 150.93,117.4 150.38,117.4 150.2,117.58 150.2,118.39 150.33,118.51 150.54,118.51 150.8,118.77 150.8,119.19 150.54,119.45 150.33,119.45 150.2,119.58 150.2,119.96 148.83,121.34 146.46,121.34 143.26,124.55 142.85,124.55 141.97,123.66 141.97,123.08 142.42,122.63 142.78,122.63 143.11,122.95 143.28,122.95 143.45,122.78 143.45,122.6 143.13,122.28 143.13,121.92 143.43,121.62 143.8,121.62 144.12,121.94 144.3,121.94 144.47,121.77 144.47,121.59 144.15,121.27 144.15,120.9 144.44,120.61 144.44,119.81 143.44,118.81 143.26,118.81 142.57,119.5 142.21,119.5 141.9,119.19 141.9,118.81 142.51,118.21 142.51,117.88 142.13,117.5 142.13,117.14 141.15,116.17 139.37,116.17 v1(139.25,116.29) 138.99,116.55 138.99,116.94 140.39,118.33 140.39,129.09 138.96,130.52 138.96,131.24 v1(139.25,131.53) 138.94,131.84 138.94,132.17 140.37,133.59 140.37,144.36 139.01,145.71 139.01,146.13 139.25,146.36 v1(139.25,146.77) 139.01,147 139.01,147.5 140.77,149.26 140.77,152.44 140.49,152.72 140.49,152.85 140.49,159.46 139.01,160.93 139.01,161.78 v1(139.25,162.01) 139.25,162.03 138.99,162.29 138.99,162.71 140.59,164.31 140.77,164.5 140.77,174.72 139.01,176.48 139.01,177.02 v1(139.25,177.25) 138.99,177.51 138.99,178.06 140.22,179.28 142.19,179.28 144.1,181.19 144.64,181.19 144.74,181.09 144.74,180.91 144.84,180.81 145.05,180.81 145.15,180.91 145.15,181.09 145.25,181.19 145.76,181.19 v2(146.14,180.81)
DDR_CK#: length 135.7
  TOP w0.102: v1(138.45,146.77) 138.45,146.64 138.18,146.37 U45.G7 ; U39.G7 138.35,161.61 138.45,161.71 v1(138.45,162.01) ; v1(138.45,177.25) 138.45,176.9 138.4,176.85 U27.G7 ; v2(146.14,181.83) 146.46,181.51 148.79,181.51 149.36,182.08 R217.1 ; U52.G7 v1(138.45,116.29) ; U49.G7 v1(138.45,131.53)
  TOP w0.127: U1.AD15 164.41,117.01 v1(163.32,117.01)
  L03_SIG1 w0.102: v2(146.14,181.83) 145.89,181.83 145.52,181.45 143.99,181.45 142.08,179.55 140.11,179.55 138.73,178.17 138.73,177.53 v1(138.45,177.25) 138.45,177.24 138.75,176.94 138.75,176.36 140.51,174.61 140.51,164.61 140.48,164.58 138.72,162.82 138.72,162.28 v1(138.45,162.01) 138.75,161.71 138.75,160.82 140.22,159.35 140.22,152.96 140.22,152.61 140.51,152.32 140.51,149.37 138.75,147.61 138.75,147.07 v1(138.45,146.77) 138.75,146.47 138.75,145.6 140.1,144.25 140.1,133.7 138.68,132.28 138.68,131.76 v1(138.45,131.53) 138.7,131.28 138.7,130.41 140.12,128.98 140.12,118.44 138.73,117.05 138.73,116.57 v1(138.45,116.29) 138.62,116.12 138.81,116.12 139.04,115.89 139.79,115.89 139.89,115.79 139.89,115.51 140,115.41 140.2,115.41 140.3,115.51 140.3,115.79 140.4,115.89 141.25,115.89 142.39,117.03 142.39,117.39 142.77,117.77 142.77,118.32 142.17,118.92 142.17,119.08 142.33,119.23 142.46,119.23 143.15,118.54 143.55,118.54 144.7,119.7 144.7,120.72 144.41,121.01 144.41,121.16 144.73,121.48 144.73,121.88 144.41,122.21 144.01,122.21 143.69,121.88 143.54,121.88 143.4,122.03 143.4,122.17 143.72,122.49 143.72,122.89 143.4,123.22 142.99,123.22 142.67,122.9 142.53,122.9 142.23,123.19 142.23,123.55 142.97,124.28 143.15,124.28 146.35,121.07 148.72,121.07 149.94,119.85 149.94,119.47 150.22,119.19 150.43,119.19 150.54,119.08 150.54,118.88 150.43,118.78 150.22,118.78 149.94,118.5 149.94,117.46 150.27,117.13 151.04,117.13 151.32,117.4 151.32,117.84 151.44,117.96 151.65,117.96 151.75,117.86 151.75,117.41 152.03,117.13 152.57,117.13 152.85,117.41 152.85,117.99 152.95,118.09 153.16,118.09 153.26,117.99 153.26,117.41 153.54,117.13 154.64,117.13 154.92,117.41 154.92,117.66 155.02,117.76 155.23,117.76 155.33,117.66 155.33,117.41 155.61,117.13 158.95,117.13 159.74,117.92 160.78,117.92 161.06,118.2 163.04,118.2 163.39,117.84 163.39,117.09 v1(163.32,117.01)
DDR_CKE: length 137.4
  TOP w0.102: v1(138.97,113.12) 138.97,113.22 138.33,113.86 138.33,114.01 U52.G9 ; U27.G9 138.28,175.02 138.28,174.96 138.33,174.9 138.33,174.31 138.56,174.08 v1(138.97,174.08) 141.61,171.44 146.08,171.44 147.31,172.67 R210.1 ; U39.G9 138.05,159.63 138.55,159.13 138.68,159.13 v1(138.97,158.84) ; U49.G9 138.68,128.9 138.68,128.65 v1(138.97,128.36) ; v1(138.97,143.6) 138.56,143.6 138.05,144.11 U45.G9 ; U1.AB18 v1(166.01,114.61)
  L03_SIG1 w0.102: v1(138.97,174.08) 139.41,173.64 139.41,166.9 138.83,166.32 138.83,163.95 138.61,163.73 138.61,163.71 138.39,163.49 138.37,163.49 137.39,162.51 137.39,161.58 138.48,160.49 138.48,159.33 v1(138.97,158.84) 139.37,158.44 139.37,150.79 138.83,150.25 138.83,148.48 137.97,147.62 137.97,146.44 137.87,146.34 137.73,146.34 137.63,146.24 137.63,145.93 137.73,145.83 138.02,145.83 138.15,145.7 138.15,144.03 138.58,143.6 v1(138.97,143.6) 138.97,142.76 139.09,142.64 139.09,137.02 139.11,137 139.11,136.53 138.66,136.08 138.66,135 137.85,134.19 137.85,132.55 137.39,132.09 137.39,130.8 138.97,129.22 v1(138.97,128.36) 139.26,128.07 139.26,120.73 138.76,120.23 138.76,118.1 137.64,116.98 137.62,116.98 137.39,116.76 137.39,116.73 137.39,116.73 137.39,115.66 138.15,114.9 138.15,113.93 v1(138.97,113.12)
  BOTTOM w0.102: v1(138.97,113.12) 138.97,112.1 139.72,111.34 139.72,109.72 139.83,109.62 140.03,109.62 140.13,109.72 140.13,110.78 140.23,110.89 140.44,110.89 140.54,110.78 140.54,109.74 140.64,109.64 140.84,109.64 140.94,109.74 140.94,110.78 141.05,110.89 141.25,110.89 141.35,110.78 141.35,109.74 141.45,109.64 141.65,109.64 141.76,109.74 141.76,110.78 141.86,110.89 142.06,110.89 142.16,110.78 142.16,109.74 142.26,109.64 142.47,109.64 142.57,109.74 142.57,110.78 142.67,110.89 142.87,110.89 142.98,110.78 142.98,109.74 143.08,109.64 143.28,109.64 143.38,109.74 143.38,110.78 143.48,110.89 144.34,110.89 144.44,110.78 144.44,110.23 144.55,110.12 144.75,110.12 144.85,110.23 144.85,110.78 144.95,110.89 145.16,110.89 145.26,110.78 145.26,110.23 145.36,110.12 145.56,110.12 145.66,110.23 145.66,110.78 145.77,110.89 145.97,110.89 146.07,110.78 146.07,110.23 146.17,110.12 146.37,110.12 146.48,110.23 146.48,110.78 146.58,110.89 147.01,110.89 147.11,110.78 147.11,110.23 147.21,110.12 147.41,110.12 147.52,110.23 147.52,110.78 147.62,110.89 147.82,110.89 147.92,110.78 147.92,110.3 148.02,110.2 148.23,110.2 148.33,110.3 148.33,110.78 148.43,110.89 149.56,110.89 152.58,113.91 153.53,113.91 154.27,114.65 157.35,114.65 157.66,114.34 158.05,114.34 158.99,113.4 162.36,113.4 162.74,113.78 162.74,114.39 163.04,114.7 164.19,114.7 164.48,114.99 165.63,114.99 v1(166.01,114.61)
DDR_CKE1: length 11.6
  TOP w0.102: TP154.1 155.93,113.45 157.55,113.45 v1(157.82,113.73) ; U1.AC18 v1(165.21,114.61)
  L08_SIG2 w0.102: v1(165.21,114.61) 164.3,114.61 163.9,114.22 163.44,114.22 162.81,113.59 161.55,113.59 161.41,113.45 158.1,113.45 v1(157.82,113.73)
DDR_CLKN_LVDS_100MHZ: length 44.9
  TOP w0.102: v2(151.69,81.78) 151.36,81.46 150.58,81.46 150.38,81.66 R18.2 ; U1.AD24 164.58,110.21 164.19,109.82 163.39,109.82 163.29,109.72 163.29,109.62 163.21,109.54 162.97,109.54 162.88,109.63 162.88,109.72 162.64,109.96 162.12,109.96 v1(162.03,109.86)
  BOTTOM w0.102: v2(151.69,81.78) 151.36,81.46 150.96,81.46 150.65,81.78 150.65,86.68 151.87,87.9 155.68,87.9 157.66,89.88 157.66,94.63 155.14,97.14 155.14,99.43 157.12,101.41 157.12,106.34 159.38,108.6 161.39,108.6 161.77,108.98 161.77,109.61 v1(162.03,109.86)
DDR_CLKP_LVDS_100MHZ: length 44.9
  TOP w0.102: R17.2 150.38,81.01 150.51,81.13 151.36,81.13 v2(151.69,80.81) ; v1(161.44,109.86) 161.44,110.02 161.67,110.25 161.95,110.25 161.98,110.29 162.8,110.29 162.94,110.15 163.94,110.15 U1.AE24
  BOTTOM w0.102: v2(151.69,80.81) 151.36,81.13 150.83,81.13 150.32,81.64 150.32,86.82 151.73,88.23 155.54,88.23 157.33,90.02 157.33,94.49 154.81,97.01 154.81,99.57 156.79,101.55 156.79,106.48 159.25,108.93 161.25,108.93 161.44,109.12 v1(161.44,109.86)
DDR_CS#: length 135.3
  TOP w0.102: v1(136.82,148.97) 136.82,149.94 137.25,150.37 U45.H2 ; U27.H2 137.25,180.85 136.82,180.42 v1(136.82,179.45) ; R209.1 v2(141.73,185.94) ; v1(136.82,118.49) 136.82,119.46 U52.H2 ; v1(136.82,133.73) 136.82,134.7 U49.H2 ; v1(162.74,119.41) 163.52,118.63 164.43,118.63 U1.AD13 ; U39.H2 137.25,165.61 136.82,165.18 v1(136.82,164.21)
  L08_SIG2 w0.102: v1(136.82,118.49) 136.82,118.9 136.82,118.9 136.82,121.16 136.93,121.27 136.93,123.55 136.83,123.66 136.45,123.66 136.35,123.76 136.35,124.06 136.45,124.16 136.83,124.16 136.93,124.27 136.93,127.46 136.83,127.56 136.83,130.69 136.12,131.4 136.12,132.38 136.82,133.09 v1(136.82,133.73) 137.21,134.12 137.21,137.88 137.16,137.93 137.16,146.98 136.91,147.23 136.25,147.23 136.14,147.33 136.14,147.63 136.25,147.73 136.67,147.73 136.73,147.79 136.73,148.47 136.82,148.56 v1(136.82,148.97) 137.16,149.31 137.16,153.15 137.08,153.23 137.08,155.44 137.18,155.54 137.92,155.54 138.02,155.64 138.02,155.95 137.92,156.05 137.18,156.05 137.08,156.15 137.08,156.6 137.26,156.79 137.26,160.52 136.76,161.02 136.76,163.74 136.82,163.8 v1(136.82,164.21) 137.24,164.63 137.24,166.98 137.34,167.08 137.69,167.08 137.79,167.18 137.79,167.49 137.69,167.59 137.34,167.59 137.24,167.69 137.24,168.16 137.57,168.49 137.57,174.13 137.24,174.46 137.24,177.6 136.75,178.08 136.75,179.38 v1(136.82,179.45) 141.73,184.36 v2(141.73,185.94)
  BOTTOM w0.102: v1(136.82,118.49) 137.11,118.2 137.46,118.2 137.92,117.74 139.32,117.74 140.46,118.89 144.26,118.89 144.39,118.76 146.74,118.76 147.96,119.98 149.17,119.98 149.43,119.72 149.43,119.22 149.56,119.09 149.95,119.09 150.03,119.17 150.03,119.78 150.13,119.88 150.43,119.88 150.53,119.78 150.53,118 150.64,117.9 150.94,117.9 151.04,118 151.04,119.78 151.14,119.88 151.45,119.88 151.54,119.79 151.54,117.99 151.65,117.87 152.73,117.87 152.84,117.97 152.84,119.78 152.94,119.88 154.05,119.88 154.15,119.78 154.15,119.57 154.1,119.52 153.55,119.52 153.34,119.32 153.34,117.97 153.44,117.87 154.53,117.87 154.81,118.15 154.81,120.36 155.14,120.69 155.14,121.1 155.24,121.2 155.45,121.2 155.55,121.1 155.55,120.69 155.65,120.59 156.46,120.59 156.56,120.49 156.56,119.8 156.66,119.7 156.87,119.7 156.97,119.8 156.97,120.48 157.22,120.74 157.64,120.74 158.14,120.23 158.35,120.23 158.45,120.33 158.45,121.07 158.55,121.17 158.78,121.17 158.88,121.07 158.88,120.41 158.98,120.31 159.19,120.31 159.29,120.41 159.29,121.07 159.39,121.17 160.15,121.17 161.21,120.11 162.05,120.11 v1(162.74,119.41)
DDR_DM0: length 75.9
  TOP w0.102: v1(146.71,175.55) 146.71,176.28 146.42,176.57 144.35,176.57 143.64,177.28 142.48,177.28 U27.B7
  TOP w0.127: U1.AB4 v1(166.01,126.61)
  L08_SIG2 w0.102: v1(166.01,126.61) 165.63,126.99 165.07,126.99 162.05,130.01 162.05,134.53 156.36,140.22 156.36,143.78 156.26,143.88 156.18,143.88 156.08,143.98 156.08,144.19 156.18,144.29 156.26,144.29 156.36,144.39 156.36,144.59 156.26,144.69 156.18,144.69 156.08,144.8 156.08,145 156.18,145.1 156.26,145.1 156.36,145.2 156.36,145.41 156.26,145.51 156.18,145.51 156.08,145.61 156.08,145.81 156.18,145.91 156.26,145.91 156.36,146.02 156.36,146.22 156.26,146.32 156.18,146.32 156.08,146.42 156.08,146.62 156.18,146.73 156.26,146.73 156.36,146.83 156.36,165.01 155.71,165.67 155.71,165.81 155.9,166.01 155.9,166.15 155.76,166.3 155.61,166.3 155.42,166.1 155.27,166.1 155.13,166.25 155.13,166.39 155.33,166.58 155.33,166.73 155.18,166.87 155.04,166.87 154.84,166.68 154.7,166.68 154.56,166.82 154.56,166.96 154.75,167.16 154.75,167.3 154.61,167.45 154.46,167.45 154.27,167.25 154.12,167.25 153.98,167.39 153.98,167.54 154.18,167.73 154.18,167.88 154.03,168.02 153.89,168.02 153.69,167.83 153.55,167.83 153.41,167.97 153.41,168.11 153.6,168.31 153.6,168.45 153.46,168.6 153.31,168.6 153.12,168.4 152.98,168.4 152.83,168.54 152.83,168.69 153.03,168.88 153.03,169.03 152.88,169.17 152.74,169.17 152.54,168.98 152.4,168.98 152.26,169.12 152.26,169.26 152.45,169.46 152.45,169.6 152.31,169.75 152.16,169.75 151.97,169.55 151.83,169.55 151.68,169.69 151.68,169.84 151.88,170.03 151.88,170.18 151.73,170.32 151.59,170.32 151.39,170.12 151.25,170.12 151.11,170.27 151.11,170.41 151.3,170.61 151.3,170.75 151.16,170.9 151.02,170.9 150.82,170.7 150.68,170.7 150.53,170.84 150.53,170.99 150.73,171.18 150.73,171.33 150.58,171.47 150.44,171.47 150.25,171.27 150.1,171.27 149.96,171.42 149.96,171.56 150.15,171.76 150.15,171.9 150.01,172.04 149.87,172.04 149.67,171.85 149.53,171.85 149.38,171.99 149.38,172.14 149.58,172.33 149.58,172.48 149.43,172.62 149.29,172.62 149.1,172.42 148.95,172.42 148.81,172.57 148.81,172.71 149,172.91 149,173.05 148.86,173.19 148.72,173.19 148.52,173 148.38,173 148.23,173.14 148.23,173.29 148.43,173.48 148.43,173.63 148.29,173.77 148.14,173.77 147.95,173.57 147.8,173.57 147.66,173.72 147.66,173.86 147.85,174.06 147.85,174.2 147.71,174.34 147.57,174.34 147.37,174.15 147.23,174.15 147.07,174.31 147.07,175.2 v1(146.71,175.55)
DDR_DM1: length 63.7
  TOP w0.102: U39.B7 142.61,162.17 143.51,162.17 144.35,161.33 146.42,161.33 146.71,161.04 v1(146.71,160.31)
  TOP w0.127: U1.AA5 v1(167.61,125.01)
  L03_SIG1 w0.102: v1(167.61,125.01) 167.61,125.27 167.48,125.39 166.62,125.39 166.37,125.64 165.15,125.64 163.86,126.94 162.08,126.94 161.04,127.98 161.04,128.21 156.92,132.32 155.8,132.32 155.37,132.76 155.37,133.97 154.44,134.9 154.44,137.59 152.96,139.07 152.96,152.67 152.17,153.46 152.07,153.46 151.67,153.06 151.53,153.06 151.38,153.2 151.38,153.35 151.74,153.7 151.74,153.89 151.59,154.04 151.45,154.04 151.15,153.74 151,153.74 150.86,153.88 150.86,154.02 151.16,154.32 151.16,154.47 151.02,154.61 150.87,154.61 150.57,154.31 150.43,154.31 150.29,154.45 150.29,154.6 150.59,154.9 150.59,155.04 150.44,155.19 150.3,155.19 150,154.88 149.85,154.88 149.71,155.03 149.71,155.17 150.01,155.47 150.01,155.62 149.87,155.76 149.72,155.76 149.42,155.46 149.28,155.46 149.14,155.6 149.14,155.75 149.44,156.05 149.44,156.19 149.29,156.33 149.15,156.33 148.85,156.03 148.7,156.03 148.56,156.18 148.56,156.32 148.86,156.62 148.86,156.77 148.72,156.91 148.57,156.91 148.27,156.61 148.13,156.61 147.99,156.75 147.99,156.9 148.29,157.2 148.29,157.34 148.14,157.48 148,157.48 147.7,157.18 147.56,157.18 147.41,157.33 147.41,157.47 147.71,157.77 147.71,157.92 147.24,158.38 146.42,158.38 146.24,158.56 146.24,158.57 145.9,158.92 145.88,158.92 145.62,159.18 145.62,159.2 145.59,159.22 145.59,159.93 145.97,160.31 v1(146.71,160.31)
DDR_DM2: length 56.7
  TOP w0.102: U45.B7 142.61,146.93 143.51,146.93 144.35,146.09 146.42,146.09 146.71,145.8 v1(146.71,145.07)
  TOP w0.127: U1.AC8 v1(166.01,123.41)
  L08_SIG2 w0.102: v1(146.71,145.07) 146.63,145 146.2,145 146.08,145.13 146.08,145.71 146.28,145.91 146.71,145.91 147.09,145.53 148.57,145.53 148.67,145.63 148.67,145.86 148.57,145.96 148.5,145.96 148.4,146.06 148.4,146.27 148.5,146.37 148.57,146.37 148.67,146.47 148.67,146.63 148.77,146.73 148.95,146.73 149.08,146.59 149.08,145.63 149.18,145.53 149.38,145.53 149.51,145.66 149.51,147.33 149.56,147.39 149.81,147.39 149.92,147.28 149.92,146.85 150.07,146.69 151,146.69 151.08,146.62 151.08,146.36 151,146.29 150.02,146.29 149.94,146.21 149.94,145.58 149.99,145.53 150.65,145.53 150.8,145.38 150.8,145.06 150.98,144.88 150.98,144.65 150.8,144.47 150.8,144.24 150.98,144.07 150.98,143.84 150.8,143.66 150.8,143.43 150.98,143.25 150.98,143.03 150.8,142.85 150.8,142.62 150.98,142.44 150.98,142.21 150.8,142.03 150.8,141.81 150.98,141.63 150.98,141.4 150.8,141.22 150.8,140.99 150.98,140.82 150.98,140.59 150.8,140.41 150.8,140.18 150.98,140 150.98,139.77 150.8,139.6 150.8,139.37 150.98,139.19 150.98,138.96 150.19,138.17 150.19,135.63 150.8,135.02 150.8,130.11 151.1,129.81 152.58,129.81 154.64,127.75 154.64,126.51 155.75,125.39 160.64,125.39 160.99,125.04 161.38,125.04 161.45,125.11 163.22,125.11 164.92,123.41 v1(166.01,123.41)
DDR_DM3: length 45.1
  TOP w0.102: v1(146.71,129.83) 146.71,129.43 146.86,129.28 146.86,128.97 147.17,128.67 148.26,128.67 148.49,128.89 148.49,130.42 148.42,130.49 146.97,130.49 146.63,130.83 146.63,130.85 144.35,130.85 143.51,131.69 142.61,131.69 U49.B7
  TOP w0.127: U1.AA9 v1(166.81,122.61)
  L03_SIG1 w0.102: v1(146.71,129.83) 146.48,130.06 146.48,130.42 146.55,130.49 147.45,130.49 147.81,130.85 148.21,130.85 148.31,130.75 148.31,130.31 148.21,130.22 147.35,130.22 147.22,130.09 147.22,129.46 147.43,129.25 147.66,129.25 148.33,129.92 148.47,129.92 148.62,129.78 148.62,129.64 148.31,129.32 148.31,129.18 148.45,129.04 148.59,129.04 148.91,129.35 149.05,129.35 149.19,129.21 149.19,129.06 148.88,128.75 148.88,128.6 149.02,128.46 149.17,128.46 149.48,128.77 149.62,128.77 149.77,128.63 149.77,128.49 149.45,128.17 149.45,128.03 149.6,127.89 149.74,127.89 150.06,128.2 150.2,128.2 150.34,128.06 150.34,127.91 150.03,127.6 150.03,127.46 150.19,127.29 150.42,127.29 150.59,127.12 150.59,126.89 151.15,126.34 151.29,126.34 151.46,126.51 151.61,126.51 151.92,126.2 151.92,125.41 152.04,125.29 153.26,125.29 153.47,125.08 153.8,125.08 155.3,123.59 158.27,123.59 158.42,123.43 160.34,123.43 160.83,123.43 161.44,122.82 164.11,122.82 164.74,122.19 166.39,122.19 v1(166.81,122.61)
DDR_DQ0: length 75.9
  TOP w0.102: v2(164.41,129.94) 165.2,129.14 165.2,128.21 U1.AD2 ; v1(147.16,180.3) 146.66,180.3 145.9,179.54 142.56,179.54 U27.B3
  L08_SIG2 w0.102: v2(164.41,129.94) 163.58,130.77 163.58,135.19 159.13,139.64 159.13,142.38 158.62,142.89 158.62,144.16 159.13,144.67 159.13,168.33 153.42,174.04 153.42,174.31 153.27,174.46 153,174.46 152.83,174.63 152.68,174.63 152.26,174.21 152.12,174.21 151.97,174.35 151.97,174.5 152.4,174.92 152.4,175.06 152.25,175.21 152.11,175.21 151.69,174.79 151.54,174.79 151.4,174.93 151.4,175.07 151.82,175.5 151.82,175.64 151.68,175.78 151.53,175.78 151.11,175.36 150.97,175.36 150.82,175.5 150.82,175.65 151.25,176.07 151.25,176.21 151.1,176.36 150.96,176.36 150.54,175.94 150.39,175.94 150.25,176.08 150.25,176.22 150.67,176.64 150.67,176.79 150.53,176.93 150.39,176.93 149.96,176.51 149.82,176.51 149.68,176.65 149.68,176.8 150.1,177.22 150.1,177.36 149.95,177.51 149.81,177.51 149.39,177.08 149.24,177.08 149.1,177.23 149.1,177.37 149.52,177.79 149.52,177.94 149.38,178.08 149.24,178.08 148.81,177.66 148.67,177.66 148.53,177.8 148.53,177.95 148.95,178.37 148.95,178.51 v1(147.16,180.3)
DDR_DQ1: length 76
  TOP w0.102: U27.C7 v1(141.65,176.45)
  TOP w0.127: U1.AA4 v1(166.81,126.61)
  L08_SIG2 w0.102: v1(141.65,176.45) 141.65,176.86 141.71,176.91 141.71,177.31 142.93,178.53 143.26,178.53 143.66,178.12 143.66,177.18 143.56,177.08 142.37,177.08 142.27,176.98 142.27,176.77 142.37,176.67 143.56,176.67 143.66,176.57 143.66,176.34 143.46,176.14 142.24,176.14 142.02,175.92 142.02,174.51 142.6,173.93 142.6,172.95 153.71,161.84 153.71,137.98 153.81,137.88 153.97,137.88 154.08,137.78 154.08,137.57 153.97,137.47 153.81,137.47 153.71,137.37 153.71,135.21 154.05,134.87 154.05,133.72 153.85,133.52 153.85,131.64 154.2,131.28 154.58,131.28 156.84,129.02 159.97,129.02 161.19,127.8 161.72,127.8 162.51,127.01 164.21,127.01 165,126.23 166.17,126.23 166.55,126.61 v1(166.81,126.61)
DDR_DQ2: length 76
  TOP w0.102: U27.C2 141.62,180.48 143.51,180.48 v2(143.89,180.1)
  TOP w0.127: U1.Y4 v1(168.41,126.61)
  L08_SIG2 w0.102: v1(168.41,126.61) 167.39,126.61 166.98,126.2 166.65,126.2 166.47,126.02 164.67,126.02 163.88,126.81 162.09,126.81 161.5,127.4 161.02,127.4 159.8,128.62 156.62,128.62 154.38,130.85 154.06,130.85 153.44,131.47 153.44,133.42 153.14,133.72 153.14,134.13 153.2,134.19 153.2,161.63 141.1,173.73 141.1,175 141.27,175.17 141.27,176.14 141.2,176.21 141.2,177.41 v2(143.89,180.1)
DDR_DQ3: length 75.7
  TOP w0.102: v1(146.2,174.67) 144.79,174.67 144.56,174.44 141.99,174.44 141.6,174.82 141.6,175.69 U27.C8
  TOP w0.127: U1.AD3 164.41,127.41 v1(163.32,127.41)
  L08_SIG2 w0.102: v1(146.2,174.67) 146.2,173.52 146.4,173.33 146.54,173.33 146.77,173.55 146.91,173.55 147.05,173.41 147.05,173.26 146.83,173.04 146.83,172.9 146.97,172.75 147.12,172.75 147.34,172.98 147.48,172.98 147.63,172.83 147.63,172.69 147.4,172.47 147.4,172.32 147.55,172.18 147.69,172.18 147.92,172.4 148.06,172.4 148.2,172.26 148.2,172.12 147.98,171.89 147.98,171.75 148.12,171.6 148.27,171.6 148.49,171.83 148.63,171.83 148.78,171.68 148.78,171.54 148.55,171.32 148.55,171.17 148.7,171.03 148.84,171.03 149.06,171.25 149.21,171.25 149.35,171.11 149.35,170.97 149.13,170.74 149.13,170.6 149.27,170.45 149.41,170.45 149.64,170.68 149.78,170.68 149.93,170.53 149.93,170.39 149.7,170.17 149.7,170.02 149.85,169.88 149.99,169.88 150.21,170.1 150.36,170.1 150.5,169.96 150.5,169.82 150.28,169.59 150.28,169.45 150.42,169.3 150.56,169.3 150.79,169.53 150.93,169.53 151.08,169.39 151.08,169.24 150.85,169.02 150.85,168.87 151,168.73 151.14,168.73 151.36,168.95 151.51,168.95 151.65,168.81 151.65,168.67 151.43,168.44 151.43,168.3 151.57,168.15 151.71,168.15 151.94,168.38 152.08,168.38 152.23,168.24 152.23,168.09 152,167.87 152,167.72 152.14,167.58 152.29,167.58 152.51,167.8 152.66,167.8 152.8,167.66 152.8,167.52 152.58,167.29 152.58,167.15 152.72,167.01 152.86,167.01 153.09,167.23 153.23,167.23 153.38,167.09 153.38,166.94 153.15,166.72 153.15,166.57 153.29,166.43 153.44,166.43 153.66,166.66 153.81,166.66 153.95,166.51 153.95,166.37 153.73,166.14 153.73,166 153.87,165.86 154.01,165.86 154.24,166.08 154.38,166.08 154.52,165.94 154.52,165.79 154.3,165.57 154.3,165.42 154.44,165.28 154.64,165.28 154.89,165.53 155.03,165.53 155.18,165.39 155.18,165.24 154.87,164.94 154.87,164.85 155.68,164.05 155.68,139.79 157.81,137.66 157.81,134.97 157.55,134.7 157.55,132.2 158.22,131.53 158.39,131.53 158.89,131.03 160.49,131.03 161.62,129.9 161.62,129.86 163.32,128.16 v1(163.32,127.41)
DDR_DQ4: length 75.9
  TOP w0.102: U27.E3 139.92,179.78 139.92,179.68 141.35,178.25 144.14,178.25 144.7,177.69 v1(147.57,177.69)
  TOP w0.127: U1.AC3 v1(166.01,127.41)
  L08_SIG2 w0.102: v1(166.01,127.41) 166.01,127.6 163.07,130.55 163.07,135.13 158.22,139.98 158.22,149.58 158.32,149.69 158.32,150.06 158.22,150.17 158.22,152.12 158.45,152.35 158.45,152.73 158.22,152.96 158.22,167.05 155.4,169.86 155.26,169.86 154.74,169.34 154.6,169.34 154.46,169.48 154.46,169.63 154.97,170.15 154.97,170.29 154.83,170.43 154.69,170.43 154.17,169.92 154.03,169.92 153.88,170.06 153.88,170.2 154.4,170.72 154.4,170.86 154.25,171.01 154.11,171.01 153.59,170.49 153.45,170.49 153.31,170.63 153.31,170.78 153.82,171.29 153.82,171.44 153.68,171.58 153.54,171.58 153.02,171.07 152.88,171.07 152.73,171.21 152.73,171.35 153.25,171.87 153.25,172.01 153.11,172.16 152.96,172.16 152.44,171.64 152.3,171.64 152.16,171.78 152.16,171.93 152.67,172.44 152.67,172.59 v1(147.57,177.69)
DDR_DQ5: length 75.9
  TOP w0.102: v1(162.74,127.41) 163.14,127.01 U1.AE3 ; U27.E8 140.08,175.62 140.08,174.64 140.74,173.98 142.88,173.98 142.91,174.02 144.23,174.02 144.24,174.02 145.2,174.02 v1(145.52,173.7)
  L08_SIG2 w0.102: v1(162.74,127.41) 162.74,128.21 160.32,130.62 158.72,130.62 158.22,131.12 158.05,131.12 157.14,132.03 157.14,134.69 155.78,136.05 155.78,138.44 155.09,139.13 155.09,162.91 154.58,163.42 154.58,163.56 154.79,163.77 154.79,163.92 154.65,164.06 154.5,164.06 154.29,163.85 154.15,163.85 153.99,164.01 153.99,164.15 154.22,164.39 154.22,164.53 154.08,164.68 153.94,164.68 153.7,164.44 153.56,164.44 153.41,164.58 153.41,164.73 153.65,164.97 153.65,165.11 153.51,165.25 153.36,165.25 153.13,165.02 152.98,165.02 152.84,165.16 152.84,165.3 153.08,165.54 153.08,165.68 152.93,165.83 152.79,165.83 152.55,165.59 152.41,165.59 152.26,165.73 152.26,165.88 152.5,166.12 152.5,166.26 152.36,166.4 152.21,166.4 151.98,166.17 151.83,166.17 151.69,166.31 151.69,166.45 151.93,166.69 151.93,166.83 151.78,166.98 151.64,166.98 151.4,166.74 151.26,166.74 151.11,166.88 151.11,167.03 151.35,167.26 151.35,167.41 151.21,167.55 151.06,167.55 150.83,167.31 150.68,167.31 150.54,167.46 150.54,167.6 150.78,167.84 150.78,167.98 150.63,168.13 150.49,168.13 150.25,167.89 150.11,167.89 149.96,168.03 149.96,168.18 150.2,168.41 150.2,168.56 150.06,168.7 149.91,168.7 149.68,168.46 149.53,168.46 149.39,168.61 149.39,168.75 149.63,168.99 149.63,169.13 149.48,169.28 149.34,169.28 149.1,169.04 148.96,169.04 148.81,169.18 148.81,169.33 149.05,169.56 149.05,169.71 148.91,169.85 148.76,169.85 148.53,169.61 148.38,169.61 148.24,169.76 148.24,169.9 148.48,170.14 148.48,170.28 148.33,170.43 148.19,170.43 147.95,170.19 147.81,170.19 147.67,170.33 147.67,170.48 147.9,170.71 147.9,170.86 147.76,171 147.62,171 147.38,170.76 147.23,170.76 147.09,170.91 147.09,171.05 147.33,171.29 147.33,171.43 147.18,171.58 147.04,171.58 146.8,171.34 146.66,171.34 146.52,171.48 146.52,171.63 146.75,171.86 146.75,172.01 146.61,172.15 146.47,172.15 146.23,171.91 146.08,171.91 145.52,172.48 v1(145.52,173.7)
DDR_DQ6: length 75.9
  TOP w0.102: U27.D2 140.85,181.25 140.85,182.67 141.45,183.28 v1(143.64,183.28)
  TOP w0.127: U1.AB3 v1(166.81,127.41)
  L08_SIG2 w0.102: v1(166.81,127.41) 166.81,128.86 164.01,131.66 164.01,135.55 159.64,139.92 159.64,169.1 155.63,173.11 155.63,173.25 156.13,173.74 156.13,173.89 155.98,174.03 155.84,174.03 155.35,173.54 155.2,173.54 155.06,173.68 155.06,173.83 155.55,174.32 155.55,174.46 155.41,174.6 155.26,174.6 154.77,174.11 154.63,174.11 153.79,174.95 153.79,175.09 153.85,175.15 153.85,175.29 153.71,175.44 153.57,175.44 153.51,175.38 153.36,175.38 153.22,175.52 153.22,175.67 153.28,175.73 153.28,175.87 153.14,176.01 152.99,176.01 152.93,175.95 152.79,175.95 145.47,183.28 v1(143.64,183.28)
DDR_DQ7: length 75.7
  TOP w0.102: U27.E7 139.65,177.23 140.18,177.76 143.87,177.76 144.55,177.08 146.82,177.08 146.82,177.08 146.92,177.08 v1(147.21,176.79) ; U1.AC2 v1(165.21,127.41)
  L08_SIG2 w0.102: v1(147.21,176.79) 147.6,176.41 147.6,175.45 147.97,175.09 148.11,175.09 148.53,175.5 148.67,175.5 148.81,175.36 148.81,175.21 148.4,174.8 148.4,174.65 148.54,174.51 148.69,174.51 149.1,174.93 149.24,174.93 149.39,174.78 149.39,174.64 148.97,174.22 148.97,174.08 149.12,173.94 149.26,173.94 149.68,174.35 149.82,174.35 149.96,174.21 149.96,174.06 149.55,173.65 149.55,173.5 149.69,173.36 149.84,173.36 150.25,173.78 150.39,173.78 150.54,173.63 150.54,173.49 150.12,173.07 150.12,172.93 150.27,172.79 150.41,172.79 150.82,173.2 150.97,173.2 151.11,173.06 151.11,172.91 150.7,172.5 150.7,172.36 150.84,172.21 150.98,172.21 151.4,172.63 151.54,172.63 151.69,172.48 151.69,172.34 151.27,171.92 151.27,171.78 156.87,166.18 156.87,149.32 156.97,149.22 157.3,149.22 157.4,149.12 157.4,148.91 157.3,148.81 156.97,148.81 156.87,148.71 156.87,148.51 156.97,148.41 157.3,148.41 157.4,148.3 157.4,148.1 157.3,148 156.97,148 156.87,147.9 156.87,140.43 162.56,134.74 162.56,130.65 165.21,128 v1(165.21,127.41)
DDR_DQ8: length 63.7
  TOP w0.102: U39.B3 142.56,164.3 145.9,164.3 146.66,165.06 v1(147.16,165.06)
  TOP w0.127: U1.Y5 v1(168.41,125.01)
  L03_SIG1 w0.102: v1(147.16,165.06) 149.45,162.77 149.45,162.62 149.06,162.23 149.06,162.08 149.2,161.94 149.34,161.94 149.74,162.34 149.88,162.34 150.03,162.19 150.03,162.05 149.63,161.65 149.63,161.51 149.77,161.37 149.92,161.37 150.32,161.76 150.46,161.76 150.6,161.62 150.6,161.47 150.21,161.08 150.21,160.93 150.35,160.79 150.49,160.79 150.89,161.19 151.03,161.19 151.18,161.04 151.18,160.9 150.78,160.5 150.78,160.36 150.92,160.22 151.07,160.22 151.46,160.61 151.61,160.61 151.75,160.47 151.75,160.33 151.36,159.93 151.36,159.78 151.5,159.64 151.64,159.64 152.04,160.04 152.18,160.04 155.17,157.05 155.17,140.06 155.96,139.27 156.84,139.27 158.7,137.4 160.29,137.4 163.4,134.3 163.4,130.11 164.54,128.97 165.56,128.97 166.4,128.13 166.4,127.24 166.62,127.01 166.95,127.01 168.41,125.55 v1(168.41,125.01)
DDR_DQ9: length 63.9
  TOP w0.102: U39.C7 v1(141.65,161.21)
  TOP w0.127: U1.AC5 v1(165.21,125.01)
  L03_SIG1 w0.102: v1(165.21,125.01) 164.8,125.01 164.4,125.41 161.32,125.41 161.24,125.49 160.35,125.49 159.79,126.05 158.47,126.05 158.19,126.33 158.19,127.08 156.98,128.28 155.96,128.28 152.91,131.33 152.73,131.33 150.61,133.46 150.61,149.56 149.27,150.9 149.18,150.9 148.68,150.41 148.54,150.41 148.4,150.55 148.4,150.69 148.84,151.13 148.84,151.33 148.69,151.47 148.55,151.47 148.11,151.03 147.97,151.03 147.82,151.18 147.82,151.32 148.26,151.76 148.26,151.9 148.12,152.05 147.98,152.05 147.54,151.61 147.39,151.61 147.25,151.75 147.25,151.89 147.69,152.33 147.69,152.48 147.54,152.62 147.4,152.62 146.96,152.18 146.82,152.18 146.67,152.33 146.67,152.47 147.11,152.91 147.11,153.05 146.97,153.2 146.83,153.2 146.39,152.76 146.24,152.76 146.1,152.9 146.1,153.04 146.54,153.48 146.54,153.63 146.39,153.77 146.25,153.77 145.81,153.33 145.67,153.33 145.52,153.47 145.52,153.62 145.96,154.06 145.96,154.2 145.82,154.35 145.68,154.35 145.24,153.91 145.09,153.91 144.95,154.05 144.95,154.19 145.39,154.63 145.39,154.78 145.25,154.92 145.1,154.92 144.66,154.48 144.52,154.48 144.37,154.62 144.37,154.77 144.81,155.21 144.81,155.35 144.67,155.5 144.53,155.5 144.09,155.06 143.94,155.06 143.8,155.2 143.8,155.34 144.24,155.78 144.24,155.93 141.96,158.21 141.96,160.9 v1(141.65,161.21)
DDR_DQ10: length 63.8
  TOP w0.102: U39.C2 141.62,165.24 143.51,165.24 v1(143.89,164.86)
  TOP w0.127: U1.AA6 v1(167.61,124.21)
  L03_SIG1 w0.102: v1(167.61,124.21) 167.22,124.6 164.69,124.6 164.21,125.08 160.18,125.08 159.62,125.64 158.16,125.64 156.59,127.21 156.59,127.6 156.31,127.88 155.47,127.88 154.15,129.2 154.15,129.48 152.73,130.9 152.44,130.9 150.1,133.25 150.1,133.36 150.09,133.37 150.09,135.65 150.09,136.8 150.09,137.81 150.09,142.9 149.99,143.01 149.56,143.01 149.45,143.11 149.45,143.31 149.56,143.41 149.99,143.41 150.09,143.51 150.09,143.72 149.99,143.82 149.56,143.82 149.45,143.92 149.45,144.12 149.56,144.22 149.99,144.22 150.09,144.33 150.09,148.12 142.6,155.62 142.6,156.81 141.48,157.93 141.48,160.34 141,160.82 141,161.56 143.89,164.45 v1(143.89,164.86)
DDR_DQ11: length 64.1
  TOP w0.102: v1(146.2,159.43) 145.27,159.43 145.12,159.58 144.04,159.58 143.66,159.2 141.94,159.2 141.6,159.53 141.6,160.45 U39.C8
  TOP w0.127: U1.AB5 v1(166.81,125.81)
  L03_SIG1 w0.102: v1(146.2,159.43) 146.75,159.43 146.83,159.35 146.83,158.89 146.93,158.79 147.14,158.79 147.24,158.89 147.24,159.3 147.36,159.43 147.6,159.43 147.8,159.22 147.8,159.08 147.61,158.89 147.61,158.75 147.75,158.6 147.9,158.6 148.09,158.79 148.23,158.79 148.46,158.56 148.46,158.42 148.26,158.23 148.26,158.08 148.41,157.94 148.55,157.94 148.75,158.13 148.89,158.13 149.04,157.99 149.04,157.85 148.84,157.65 148.84,157.51 148.98,157.36 149.13,157.36 149.32,157.56 149.47,157.56 149.61,157.41 149.61,157.27 149.41,157.08 149.41,156.93 149.56,156.79 149.7,156.79 149.9,156.98 150.04,156.98 150.18,156.84 150.18,156.7 149.99,156.5 149.99,156.36 150.13,156.21 150.28,156.21 150.47,156.41 150.62,156.41 150.76,156.27 150.76,156.12 150.56,155.93 150.56,155.78 150.71,155.64 150.85,155.64 151.05,155.83 151.19,155.83 151.33,155.69 151.33,155.55 151.14,155.35 151.14,155.21 151.28,155.06 151.43,155.06 151.62,155.26 151.77,155.26 151.91,155.12 151.91,154.97 151.71,154.78 151.71,154.63 151.86,154.49 152,154.49 152.2,154.68 152.34,154.68 152.48,154.54 152.48,154.4 152.29,154.2 152.29,154.06 152.43,153.91 152.58,153.91 152.93,154.27 153.16,154.27 153.47,153.96 153.47,153.1 153.64,152.92 153.64,152.69 153.47,152.51 153.47,152.28 153.64,152.11 153.64,151.88 153.47,151.7 153.47,151.47 153.64,151.29 153.64,151.07 153.47,150.89 153.47,150.66 153.64,150.48 153.64,150.25 153.47,150.08 153.47,149.85 153.64,149.67 153.64,149.44 153.47,149.26 153.47,149.03 153.64,148.86 153.64,148.63 153.47,148.45 153.47,148.22 153.64,148.04 153.64,147.81 153.47,147.64 153.47,147.41 153.64,147.23 153.64,147 153.47,146.82 153.47,146.6 153.64,146.42 153.64,146.19 153.47,146.01 153.47,145.78 153.64,145.6 153.64,145.38 153.47,145.2 153.47,144.97 153.64,144.79 153.64,144.56 153.47,144.39 153.47,144.16 153.64,143.98 153.64,143.75 153.47,143.57 153.47,143.34 153.64,143.17 153.64,142.94 153.47,142.76 153.47,142.53 153.64,142.35 153.64,142.12 153.47,141.95 153.47,141.72 153.64,141.54 153.64,141.31 153.47,141.13 153.47,140.91 153.64,140.73 153.64,140.5 153.47,140.32 153.47,139.28 154.95,137.8 154.95,135.13 155.2,134.89 155.61,134.89 155.71,134.99 155.71,135.47 155.82,135.57 156.02,135.57 156.12,135.47 156.12,134.99 156.22,134.89 156.77,134.89 157.43,134.23 157.43,132.48 158.04,131.87 158.04,131.86 158.35,131.56 158.35,131.55 160.73,129.17 161.67,129.17 162.93,127.92 163.74,127.92 164.11,127.55 164.11,127.12 165.38,125.85 166.45,125.85 166.49,125.81 v1(166.81,125.81)
