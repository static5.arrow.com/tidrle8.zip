# Allegro board MS_TI_EVMK2G_REVD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DVDD18: length 336.6
  TOP w0.254: v1(170.81,125.01) U1.U6 ; U46.9 v2(246.03,140.85)
  TOP w0.381: R381.1 248.15,140.85 v2(246.03,140.85) ; C229.2 195.2,107.84 v2(194.69,108.35) ; U1.G6 v1(178.01,125.01) ; v2(169.68,101.73) 169.17,102.25 FB27.1 ; U1.U18 v1(170.01,114.61) U1.V19 ; U1.L6 v1(174.81,124.21) U1.M7 ; U1.J6 v1(176.41,125.01) ; U1.W6 v1(169.21,124.21) ; U1.L20 v1(174.81,113.81) ; C225.2 194.34,109.11 v2(194.23,109.01) ; U1.K19 v1(175.61,114.61) ; U1.F17 v1(178.81,115.41) ; U1.F19 v1(178.81,113.81)
  TOP w0.508: v2(178.44,148.48) 178.44,149.57 177.9,150.1 177.9,154.3 C177.1 ; C177.1 178.59,154.55 178.99,154.14 178.99,150.22 v2(180.49,148.73) ; C177.1 177.7,154.6 v2(177.7,156.89) ; v2(174.32,138.67) 173.48,137.83 173.48,136.79 172.24,135.55 169.9,135.55 169.11,136.34 164.87,136.34 163.58,137.63 v2(163.58,139.59)
  L03_SIG1 w0.305: v1(174.81,124.21) 175.61,125.01 v1(176.41,125.01) v1(178.01,125.01)
  L03_SIG1 w0.381: v2(178.44,148.48) 176.78,146.83 176.78,145.56 175.26,144.03 175.26,142.75 175.26,142.75 175.26,142.24 175.26,142.08 173.58,140.4 173.58,139.4 v2(174.32,138.67)
  L03_SIG1 w0.508: v2(182.85,139.56) 183.42,139.56 183.55,139.7 183.56,139.7 183.71,139.84 183.76,139.84 183.88,139.97 183.88,140.11 183.9,140.12 183.9,140.68 183.49,141.09 183.11,141.09 182.63,141.57 182.63,145.2 v2(182.42,145.4)
  L05_PWR1 w0.102: 174.4,124.63 171.25,124.63 170.86,125.01 170.85,125.01 ; 174.4,124.63 174.42,124.65 174.42,125.18 174.17,125.43 173.05,125.43 171.26,125.43 170.85,125.01 ; 174.4,124.63 v1(174.81,124.21) ; 170.85,125.01 v1(170.81,125.01) ; 170.69,104.03 170.69,104.36 170.39,104.66 170.39,110.77 170.36,110.8 170.36,111.22 170.39,111.26 170.39,111.57 170.36,111.6 170.36,112.82 170.39,112.86 170.39,113.17 170.36,113.2 170.36,113.62 170.39,113.66 170.39,113.97 170.36,114 170.36,114.24 170.01,114.59 v1(170.01,114.61) 169.6,114.2 169.6,103.88
  L05_PWR1 w0.127: v1(178.01,125.01) 178.01,125.04 178.38,125.41 185.22,125.41 185.67,124.96 185.34,124.62 178.32,124.62 178.01,124.93 v1(178.01,125.01)
  L05_PWR1 w0.381: 170.69,104.03 170.69,102.74 v2(169.68,101.73) 169.68,102.01 169.6,102.1 169.6,103.88 ; 185.67,124.96 187.55,124.96 v1(188.29,124.21) 188.29,123.08 189.23,122.14 189.23,120.77 190.83,119.17 194.23,119.17 v2(194.64,119.57) 195.05,119.17 195.05,117.26 193.6,115.81 193.6,111.6 194.64,110.56 194.64,109.41 v2(194.23,109.01)
  L08_SIG2 w0.102: v1(175.61,114.61) U1.K19 178.39,114.21 178.55,114.05 178.57,114.05 v1(178.81,113.81) 178.4,113.4 175.22,113.4 175.03,113.59 175.03,113.59 v1(174.81,113.81)
  L08_SIG2 w0.127: v1(170.81,125.01) 170.42,125.41 169.85,125.41 169.62,125.18 169.62,124.62 170.42,124.62 ; 170.01,114.86 170.4,115.25 170.4,123.25 170.4,123.58 170.17,123.81 169.85,123.81 169.85,123.81 169.62,123.81 169.62,115.01 v1(170.01,114.61) 170.01,114.86 ; 178.16,119.81 177.85,119.81 177.62,119.58 177.62,116.11 177.34,115.84 176.83,115.84 176.82,115.82 176.82,119.58 177.05,119.81 177.36,119.81 177.6,120.05 177.6,124.61 v1(178.01,125.01) 178.4,124.62 178.4,120.05 178.16,119.81
  L08_SIG2 w0.152: 170.42,124.62 v1(170.81,125.01)
  L08_SIG2 w0.305: 169.62,123.81 v1(169.21,124.21) 169.62,124.62 ; v1(174.81,113.81) v1(175.61,114.61) 176.82,115.82
  L08_SIG2 w0.381: 180.85,149.67 181.69,149.67 182.17,149.19
  L08_SIG2 w0.508: J42.2 240.59,145.89 240.59,147.67 238.38,149.87 228.27,149.87 v2(228.04,150.1) ; 180.85,149.67 180.49,149.3 v2(180.49,148.73) ; v2(182.42,145.4) 182.14,145.68 181.86,145.68 181.36,146.19 181.36,147.46 182.17,148.27 182.17,149.19
  BOTTOM w0.127: v1(169.21,124.21) 169.62,123.81 169.62,121.82 ; 165.39,125.53 165.42,125.53 165.55,125.41 170.41,125.41 v1(170.81,125.01) ; v1(178.81,115.41) 179.2,115.02 179.2,114.21 v1(178.81,113.81) 178.4,114.22 178.4,115.01 v1(178.81,115.41)
  BOTTOM w0.152: 169.62,121.82 C244.2
  BOTTOM w0.254: FB28.1 171.86,102.22 171,101.37 FB29.1 170.05,101.37 v2(169.68,101.73)
  BOTTOM w0.381: FB21.1 182.63,145.2 v2(182.42,145.4) ; FB24.1 189.23,123.27 v1(188.29,124.21) 188.24,124.26 188.24,125.35 188.65,125.75 FB23.1 ; FB19.1 182.67,139.38 v2(182.85,139.56) ; 164.47,126.46 165.39,125.53 ; C600.1 194.82,108.22 v2(194.69,108.35) 194.69,108.55 v2(194.23,109.01) 194.97,109.74 C597.2 ; v2(194.64,119.57) 194.24,119.17 193,119.17 FB25.1
  BOTTOM w0.508: 246.13,141.87 245.75,142.25 243.97,142.25 243.46,142.76 243.46,143.02 J42.2 ; 246.13,141.87 246.14,141.86 C722.2 ; 246.13,141.87 246.13,140.94 v2(246.03,140.85) ; v2(177.7,156.89) 178.97,158.16 219.94,158.16 227.41,150.69 227.46,150.69 v2(228.04,150.1) ; 164.47,126.46 164.47,128.49 165.1,129.12 165.1,130.37 163.58,131.89 v2(163.58,139.59) 163.09,139.11 FB20.1 ; FB17.1 v2(174.32,138.67)
DVDD33: length 61.3
  TOP w0.127: U1.AA23 v1(166.81,110.61)
  TOP w0.254: 276.1,151.04 276.06,151.01 U42.9
  TOP w0.381: U1.R6 v1(171.61,124.21) U1.T7 ; U1.H15 v1(177.21,117.81) ; v2(190.63,108.22) 190.63,107.96 191.6,106.99 C231.2 ; U1.T23 v1(170.81,110.61) ; U1.E23 v1(179.61,110.61) ; U1.T19 v1(170.81,113.81) U1.U20 v1(170.01,113.01) U1.V21 ; U1.H17 v1(178.01,115.41) U1.G18 ; U1.G16 v1(178.01,117.01) ; C224.2 190.98,109.95 v2(190.12,110.81) ; U1.H9 v1(178.01,121.81) ; U1.P7 v1(172.41,123.41) ; 276.1,151.04 276.53,150.61 278.74,150.61 ; U1.R20 v1(172.41,113.81) U1.P19 ; U1.G20 v1(178.01,113.81) ; U1.F15 v1(178.81,117.01) ; U1.F11 v1(178.81,120.21) U1.G12 v1(178.01,120.21) U1.H11 ; C178.2 v2(166.75,137.46) ; U1.F7 v1(178.81,124.21) ; C179.2 v2(168.27,137.46) ; C185.2 v2(169.8,137.46) ; C187.2 v2(165.23,137.46) ; U1.F21 v1(178.81,112.21) ; U1.J20 v1(176.41,113.81) ; U1.H13 v1(177.21,119.41)
  L06_PWR2 w0.508: 271.6,156.48 J39.2 ; J39.2 272.67,155.41 ; J39.2 272.67,157.55
  BOTTOM w0.127: C252.2 179.94,123.81 179.04,123.81 178.81,124.05 v1(178.81,124.21) 178.81,124.26 179.15,124.61 179.9,124.61 180.11,124.4 180.15,124.4 C252.2
  BOTTOM w0.305: C253.2 169.3,113.72 v1(170.01,113.01)
  BOTTOM w0.381: C596.2 191.53,111.37 190.25,111.37 190.12,111.24 v2(190.12,110.81) ; C242.2 166.81,109.89 v1(166.81,110.61) ; C179.2 v2(168.27,137.46) ; v2(277.75,148.99) 278,149.24 C714.2 ; v1(168.41,105.6) 167.96,106.05 C197.1 ; v1(166.01,133.69) 166.44,134.12 C538.1 ; C585.1 v2(207.7,119.98) ; C585.1 208.49,121.37 208.76,121.1 v2(208.76,119.95) ; C585.1 207.08,121.37 206.65,120.94 v2(206.65,120) ; C613.1 174.57,104.58 v2(174.81,104.33) ; C178.2 v2(166.75,137.46) ; C621.2 172.71,123.71 v1(172.41,123.41) ; C614.2 179.57,110.57 v1(179.61,110.61) ; C588.1 182.9,104.42 v2(182.81,104.33) ; v1(166.01,131.15) 166.28,131.42 C539.1 ; v1(170.81,110.61) 171.43,110 C615.1 ; v1(178.01,106.87) 178.05,106.83 C243.1 ; C616.1 169.89,105.72 v1(170.01,105.6) ; C617.2 171.54,124.14 v1(171.61,124.21) ; C609.2 v2(190.63,108.22) 190.5,108.09 190.5,107.05 190.96,106.59 C564.1
  vias: v2(274.95,127.65) v2(274.95,126.38) v2(276.22,127.65) v2(276.22,126.38) v2(277.5,127.65) v2(277.5,126.38) v2(278.76,148.99) v2(278.76,127.65) v2(278.76,126.38) v2(279.78,148.99) v2(280.03,127.65) v2(280.03,126.38) v2(280.8,148.99) v2(280.92,150.51) v2(280.92,149.75) v2(281.31,127.65) v2(281.31,126.38) v2(281.94,149.75) v2(282.07,151.4) v2(282.07,150.51) v2(282.57,127.65) v2(282.57,126.38) v2(283.84,127.65) v2(283.84,126.38)
DVDD_DDR: length 65.4
  TOP w0.102: U1.AE8 163.14,123.01 v1(162.74,123.41)
  TOP w0.127: U1.AE14 161.87,118.21 v1(161.47,117.81) ; v1(163.32,121.01) 163.85,121.01 163.86,121.01 164.41,121.01 U1.AD11 ; v1(162.05,114.61) 164.41,114.61 U1.AD18 ; v1(163.32,125.81) 164.41,125.81 U1.AD5
  TOP w0.203: 255.12,139.71 U48.9 258.18,139.71 v2(258.19,139.71)
  TOP w0.254: v1(161.47,117.81) 161.45,117.83 C202.1
  TOP w0.381: U1.V7 v1(170.01,123.41) U1.U8 ; U1.U14 v1(170.01,117.81) U1.V15 v1(169.21,117.01) U1.W16 ; C203.2 v2(152.53,122.82) ; U1.U10 v1(170.01,121.01) U1.V11 v1(170.01,120.21) U1.U12 v1(170.01,119.41) U1.V13 ; C209.2 v2(156.08,127.4) ; U1.V17 v1(169.21,115.41) U1.W18 ; C598.2 155.91,124.35 v2(156.08,124.53) ; v2(157.07,129.5) 157.05,129.48 155.98,129.48 155.7,129.76 C227.1 155.7,130.29 155.96,130.55 157.53,130.55 157.98,130.09 v2(157.98,129.52) ; C208.2 v2(152.4,125.87) ; J43.2 254,140.82 255.12,139.71
  L05_PWR1 w0.508: 254,143.47 J43.2 ; J43.2 252.93,144.54 ; J43.2 254,145.61 ; J43.2 255.07,144.54
  L06_PWR2 w0.127: 168,120.61 168.02,120.64
  BOTTOM w0.381: C574.2 162.63,123.3 v1(162.74,123.41) ; v1(170.01,117.81) 169.62,117.43 C212.1 ; v1(163.32,125.81) 163.32,125.33 C199.2 ; C725.2 266.45,139.89 265.81,139.26 v2(265.81,138.44) ; C230.2 153.02,123.46 152.02,123.46 v2(151.38,122.82) ; C598.2 154.95,124.36 155.32,124.73 156.72,124.73 v2(157.23,124.53) ; v2(151.26,125.87) 151.89,126.51 153.02,126.51 C601.2 ; C226.1 162.14,114.53 v1(162.05,114.61) ; v1(161.47,117.81) 161.28,117.63 C198.2 ; v1(170.01,121.01) 170.5,120.52 C573.1 ; C566.2 163.57,121.26 v1(163.32,121.01) ; v2(157.23,127.4) 156.59,128.03 155.45,128.03 154.95,127.54 C565.2 ; v1(170.01,120.21) 169.46,120.21 C576.1
  vias: v2(265.68,137.68) v2(266.57,138.44) v2(266.57,137.68) v2(267.33,138.44) v2(267.33,137.68) v2(268.1,138.44) v2(268.1,137.68) v2(268.86,138.44) v2(268.86,137.68)
DVDD_DDRPLL: length 42.6
  TOP w0.127: U1.W8 v1(168.41,122.61) ; U1.W10 v1(168.41,121.01) ; U1.W14 v1(168.41,117.81)
  TOP w0.381: C557.2 156.48,132.73 156.51,132.77 156.51,132.78 v2(156.49,132.78)
  L08_SIG2 w0.127: v1(168.41,121.01) 168.8,120.62 168.8,118.21 v1(168.41,117.81) 168.02,118.21 168.02,120.62 v1(168.41,121.01) ; v1(168.41,121.01) 168.8,121.41 168.8,122.22 v1(168.41,122.61) 168.02,122.22 168.02,121.41 v1(168.41,121.01)
  BOTTOM w0.127: 168,123.02 165.54,123.02 165.42,123.13 165.34,123.13
  BOTTOM w0.152: 168,123.02 v1(168.41,122.61)
  BOTTOM w0.381: 156.51,132.78 156.51,132.95 156.59,133.02 156.59,134.28 ; 156.51,132.78 156.51,132.77 156.59,132.77 ; 156.51,132.78 v2(156.49,132.78) ; 156.59,131.84 156.59,132.77 ; 156.59,131.84 157.23,131.84 159.64,129.43 159.64,127.78 160.78,126.63 163.32,126.63 164.13,125.82 164.13,124.34 165.34,123.13 ; 156.59,131.84 156.51,131.92 C190.2 ; 156.59,132.77 156.56,132.73 C557.2 ; 156.59,134.28 156.21,133.9 C552.1 ; 156.59,134.28 156.59,134.38 156.09,134.89 C189.1 156.09,138.8 156.41,139.13 157.21,139.13 FB20.2
GND_AUD_OSC: length 14.4
  TOP w0.127: v1(184.48,116.21) 184.32,116.37 183.54,116.37 183.38,116.21 182.81,116.21 U1.B17
  BOTTOM w0.381: C223.1 190.97,118.01 v2(190.6,117.64) ; v2(191.39,113.3) 191.63,113.54 C220.1 197.14,113.54 198.12,114.52 R720.1 198.66,115.15 199.16,115.15 v2(199.34,115.33)
GND_CAN0: length 87.1
  TOP w0.381: C353.2 16.13,195.16 v2(16.15,195.19) ; C347.2 19.16,193.93 17.16,195.93 U105.3 ; U118.4 v2(27.05,180.28) ; P2.3 13.54,199.79 v2(16.13,197.2) 16.38,196.94 U105.3 ; U105.3 17.16,200.01 18.03,200.88 v2(21.19,200.88) U100.5 ; U118.5 v2(27.05,177.74)
  TOP w0.508: P2.6 8.84,204.99 ; P2.6 9.89,203.94 ; P2.6 8.84,202.88 ; P2.6 7.79,203.94 ; P2.5 12.74,194.25 ; P2.5 10.63,194.25 ; P2.5 11.68,195.3 ; 10.63,199.79 P2.3 11.68,198.73
  L02_GND1 w0.508: 10.63,199.79 P2.3 ; P2.3 12.74,199.79 ; P2.3 11.68,198.73 ; P2.3 11.68,200.84 ; 8.84,202.88 P2.6 ; P2.6 7.79,203.94 ; P2.6 8.84,204.99 ; P2.6 9.89,203.94 ; 10.63,194.25 P2.5 ; P2.5 11.68,195.3 ; P2.5 11.68,193.19 ; P2.5 12.74,194.25
  L04_GND2 w0.508: 11.68,198.73 P2.3 ; P2.3 12.74,199.79 ; P2.3 11.68,200.84 ; P2.3 10.63,199.79 ; 8.84,202.88 P2.6 ; P2.6 8.84,204.99 ; P2.6 9.89,203.94 ; P2.6 7.79,203.94 ; 10.63,194.25 P2.5 ; P2.5 12.74,194.25 ; P2.5 11.68,193.19 ; P2.5 11.68,195.3
  L07_GND3 w0.508: 10.63,199.79 P2.3 ; P2.3 11.68,200.84 ; P2.3 12.74,199.79 ; P2.3 11.68,198.73 ; 10.63,194.25 P2.5 ; P2.5 12.74,194.25 ; P2.5 11.68,193.19 ; P2.5 11.68,195.3 ; P2.6 8.84,204.99 ; P2.6 8.84,202.88 ; P2.6 9.89,203.94 ; P2.6 7.79,203.94
  L09_GND4 w0.508: P2.6 8.84,204.99 ; P2.6 9.89,203.94 ; P2.6 7.79,203.94 ; P2.6 8.84,202.88 ; 11.68,193.19 P2.5 ; P2.5 10.63,194.25 ; P2.5 11.68,195.3 ; P2.5 12.74,194.25 ; P2.3 12.74,199.79 ; P2.3 11.68,200.84 ; P2.3 11.68,198.73 ; P2.3 10.63,199.79
  BOTTOM w0.381: C753.2 34.65,180.05 v2(34.62,180.08)
  vias: v2(8.61,218.91) v2(11.73,218.81)
GND_CAN1: length 101.2
  TOP w0.381: v2(23.58,156.9) C345.2 22.81,157.8 22.22,158.39 U104.3 ; P3.5 12.87,150.27 C352.2 15.34,155.89 14.25,156.99 P3.3 ; U98.5 22.83,165.42 22.22,164.8 U104.3 ; U104.3 v2(21.31,161.48) ; v2(32.13,141.47) 30.26,141.47 30.01,141.72 U119.5 27.65,141.72 27.28,142.09 27.28,143.7 27.84,144.26 U119.4
  TOP w0.508: P3.5 11.68,152.5 ; P3.5 12.74,151.45 ; P3.5 11.68,150.4 ; 8.84,160.09 P3.6 ; P3.6 7.79,161.14 ; P3.6 8.84,162.19 ; P3.6 9.89,161.14 ; 11.68,155.93 P3.3 10.63,156.99
  L02_GND1 w0.508: P3.5 11.68,152.5 ; P3.5 12.74,151.45 ; P3.5 11.68,150.4 ; P3.5 10.63,151.45 ; 11.68,155.93 P3.3 ; P3.3 10.63,156.99 ; P3.3 12.74,156.99 ; P3.3 11.68,158.04 ; P3.6 8.84,162.19 ; P3.6 8.84,160.09 ; P3.6 9.89,161.14 ; P3.6 7.79,161.14
  L04_GND2 w0.508: 8.84,160.09 P3.6 ; P3.6 7.79,161.14 ; P3.6 9.89,161.14 ; P3.6 8.84,162.19 ; 10.63,151.45 P3.5 ; P3.5 11.68,152.5 ; P3.5 12.74,151.45 ; P3.5 11.68,150.4 ; P3.3 12.74,156.99 ; P3.3 11.68,155.93 ; P3.3 10.63,156.99 ; P3.3 11.68,158.04
  L07_GND3 w0.508: P3.3 11.68,158.04 ; P3.3 10.63,156.99 ; P3.3 11.68,155.93 ; P3.3 12.74,156.99 ; P3.6 9.89,161.14 ; P3.6 8.84,162.19 ; P3.6 7.79,161.14 ; P3.6 8.84,160.09 ; 10.63,151.45 P3.5 ; P3.5 11.68,152.5 ; P3.5 12.74,151.45 ; P3.5 11.68,150.4
  L09_GND4 w0.508: P3.5 11.68,152.5 ; P3.5 11.68,150.4 ; P3.5 12.74,151.45 ; P3.5 10.63,151.45 ; P3.6 9.89,161.14 ; P3.6 7.79,161.14 ; P3.6 8.84,162.19 ; P3.6 8.84,160.09 ; 11.68,155.93 P3.3 ; P3.3 12.74,156.99 ; P3.3 11.68,158.04 ; P3.3 10.63,156.99
  BOTTOM w0.381: v2(32.13,141.47) C755.2 ; R583.2 v2(10.24,178.35)
  vias: v2(8.79,177.64) v2(11.56,177.69)
GND_DB9: length 88.4
  L02_GND1 w0.508: 8.05,126.48 P1.11 ; P1.11 10.26,124.27 ; P1.11 10.26,128.69 ; P1.11 12.47,126.48 ; 8.05,101.49 P1.10 ; P1.10 10.26,103.7 ; P1.10 12.47,101.49 ; P1.10 10.26,99.28
  L03_SIG1 w0.508: P1.10 10.26,103.7 ; P1.10 12.47,101.49 ; P1.10 10.26,99.28 ; P1.10 8.05,101.49 ; P1.11 12.47,126.48 ; P1.11 10.26,124.27 ; P1.11 8.05,126.48 ; P1.11 10.26,128.69
  L04_GND2 w0.508: 8.05,101.49 P1.10 ; P1.10 10.26,99.28 ; P1.10 10.26,103.7 ; P1.10 12.47,101.49 ; 10.26,124.27 P1.11 ; P1.11 10.26,128.69 ; P1.11 12.47,126.48 ; P1.11 8.05,126.48
  L09_GND4 w0.508: 8.05,126.48 P1.11 ; P1.11 10.26,128.69 ; P1.11 10.26,124.27 ; P1.11 12.47,126.48 ; 10.26,99.28 P1.10 ; P1.10 12.47,101.49 ; P1.10 10.26,103.7 ; P1.10 8.05,101.49
  BOTTOM w0.508: 8.05,126.48 P1.11 ; P1.11 10.26,128.69 ; P1.11 12.47,126.48 ; P1.11 10.26,124.27 ; 8.05,101.49 P1.10 ; P1.10 10.26,103.7 ; P1.10 12.47,101.49 ; P1.10 10.26,99.28
GND_EARTH: length 23
  TOP w0.381: J31.16 179.5,20.97 179.88,21.35 C351.2
  BOTTOM w0.508: J31.16 176.35,22.09 163.09,22.09 J31.15 160.35,20.97 159.84,20.46 C349.2
GND_HDMI: length 94.5
  L04_GND2 w0.508: 78.32,15.6 J36.21 ; J36.21 79.5,16.78 ; J36.21 80.68,15.6 ; J36.21 79.5,14.42 ; 94,14.42 J36.20 ; J36.20 92.82,15.6 ; J36.20 95.18,15.6 ; J36.20 94,16.78 ; 78.9,9.52 J36.23 ; J36.23 77.72,10.7 ; J36.23 78.9,11.88 ; J36.23 80.08,10.7 ; J36.22 94.6,11.88 ; J36.22 93.42,10.7 ; J36.22 95.78,10.7 ; J36.22 94.6,9.52
  L07_GND3 w0.508: 94.6,9.52 J36.22 ; J36.22 95.78,10.7 ; J36.22 94.6,11.88 ; J36.22 93.42,10.7 ; J36.21 79.5,16.78 ; J36.21 78.32,15.6 ; J36.21 79.5,14.42 ; J36.21 80.68,15.6 ; 78.9,9.52 J36.23 ; J36.23 78.9,11.88 ; J36.23 80.08,10.7 ; J36.23 77.72,10.7 ; 92.82,15.6 J36.20 ; J36.20 94,16.78 ; J36.20 95.18,15.6 ; J36.20 94,14.42
  L08_SIG2 w0.508: J36.21 79.5,16.78 ; J36.21 78.32,15.6 ; J36.21 80.68,15.6 ; J36.21 79.5,14.42 ; J36.22 94.6,11.88 ; J36.22 93.42,10.7 ; J36.22 95.78,10.7 ; J36.22 94.6,9.52 ; 92.82,15.6 J36.20 ; J36.20 95.18,15.6 ; J36.20 94,14.42 ; J36.20 94,16.78 ; J36.23 80.08,10.7 ; J36.23 77.72,10.7 ; J36.23 78.9,11.88 ; J36.23 78.9,9.52
  L09_GND4 w0.508: J36.23 78.9,11.88 ; J36.23 77.72,10.7 ; J36.23 80.08,10.7 ; J36.23 78.9,9.52 ; J36.21 79.5,16.78 ; J36.21 79.5,14.42 ; J36.21 78.32,15.6 ; J36.21 80.68,15.6 ; 92.82,15.6 J36.20 ; J36.20 94,14.42 ; J36.20 95.18,15.6 ; J36.20 94,16.78 ; J36.22 95.78,10.7 ; J36.22 94.6,11.88 ; J36.22 94.6,9.52 ; J36.22 93.42,10.7
  BOTTOM w0.508: J36.21 80.68,15.6 ; J36.21 79.5,14.42 ; J36.21 78.32,15.6 ; J36.21 79.5,16.78 ; 94,14.42 J36.20 ; J36.20 94,16.78 ; J36.20 95.18,15.6 ; J36.20 92.82,15.6 ; J36.23 80.08,10.7 ; J36.23 77.72,10.7 ; J36.23 78.9,11.88 ; J36.23 78.9,9.52 ; 93.42,10.7 J36.22 ; J36.22 95.78,10.7 ; J36.22 94.6,9.52 ; J36.22 94.6,11.88
GND_MIPI: length 21.7
  TOP w0.381: R349.2 228.87,77.61 J19.62 J19.64 J19.63 J19.61
GND_OSC: length 7
  TOP w0.102: U20.D18 79.21,199.51 79.85,199.51
  TOP w0.127: 79.85,199.51 80.9,200.56 v1(80.9,200.93)
  TOP w0.381: C80.2 v2(86.72,198.36) ; C72.2 v2(86.72,205.45)
  BOTTOM w0.381: R652.1 v2(92.46,202.96)
GND_PCIE: length 3.1
  TOP w0.254: 209.17,217.95 208.53,218.58 FL2.2
GND_R: length 7.3
  TOP w0.254: U41.10 221.8,102.2 221.48,102.51 R354.2 221.48,103.9 222.11,104.54 222.88,104.54 223.25,104.17 223.25,102.42 223.3,102.37 U41.7
GND_SDCD: length 18.2
  TOP w0.381: J37.10 244.04,20.41 242.63,19 J37.11 231.98,19 v2(231.86,19.11) ; J37.14 247.45,8.2 v2(247.7,8.45) ; J37.13 231.98,8.65 v2(231.86,8.76)
GND_SYS: length 15.6
  TOP w0.254: U1.AD19 v1(164.41,113.81)
  BOTTOM w0.381: R724.1 152.65,107.86 152.98,108.19 154.27,108.19 154.65,108.57 Y6.4 ; R724.1 152.7,107.47 v2(153.66,107.47) ; R724.1 151.98,107.52 151.84,107.66 151.84,111.44 152.13,111.73 Y6.2 ; C232.2 156.58,113.21 v2(157.38,112.41) ; C234.2 156.53,108.84 157.61,109.92 157.61,110.39 157.92,110.71 v2(158.5,110.71)
GND_USB_XDS: length 35.9
  TOP w0.381: J1.6 254.53,8.83 254.53,13.43 254.22,13.73 U3.4
  L07_GND3 w0.508: J1.7 261.82,10.4 ; J1.7 260.74,8.81 ; J1.7 262.89,8.81 ; J1.6 255.59,8.81 ; J1.6 253.44,8.81 ; J1.6 254.52,10.4
  L08_SIG2 w0.508: 253.44,8.81 J1.6 ; J1.6 255.59,8.81 ; J1.6 254.52,10.4 ; J1.7 262.89,8.81 ; J1.7 261.82,10.4 ; J1.7 260.74,8.81
  L09_GND4 w0.508: J1.6 254.52,10.4 ; J1.6 255.59,8.81 ; J1.6 253.44,8.81 ; J1.7 262.89,8.81 ; J1.7 261.82,10.4 ; J1.7 260.74,8.81
  BOTTOM w0.508: J1.6 254.52,10.4 ; J1.6 255.59,8.81 ; J1.6 253.44,8.81 ; 260.74,8.81 J1.7 ; J1.7 261.82,10.4 ; J1.7 262.89,8.81
  vias: v2(263.14,10.56) v2(263.14,9.16)
GNDSHLD0: length 17.7
  BOTTOM w0.762: P2.10 12.47,187.29 ; P2.10 10.26,185.08 ; P2.10 8.05,187.29 ; P2.10 10.26,189.5 ; 10.26,210.07 P2.11 ; P2.11 8.05,212.28 ; P2.11 12.47,212.28 ; P2.11 10.26,214.49
GNDSHLD1: length 17.7
  BOTTOM w0.762: P3.11 10.26,171.69 ; P3.11 12.47,169.48 ; P3.11 8.05,169.48 ; P3.11 10.26,167.27 ; 8.05,144.49 P3.10 ; P3.10 10.26,146.7 ; P3.10 10.26,142.28 ; P3.10 12.47,144.49
GNDUSB: length 6.7
  TOP w0.381: 2.64,56.18 J23.8 J23.9 v2(9.3,56.18)
  vias: v2(9.3,66.03)
GNDUSB0: length 80.5
  L02_GND1 w0.508: 209.24,15.57 J35.5 ; J35.5 210.91,17.24 ; J35.5 207.56,17.24 ; J35.5 209.24,18.92 ; J35.6 224.05,17.24 ; J35.6 222.38,18.92 ; J35.6 220.7,17.24 ; J35.6 222.38,15.57
  L04_GND2 w0.508: 220.7,17.24 J35.6 ; J35.6 222.38,15.57 ; J35.6 224.05,17.24 ; J35.6 222.38,18.92 ; 209.24,15.57 J35.5 ; J35.5 207.56,17.24 ; J35.5 209.24,18.92 ; J35.5 210.91,17.24
  L07_GND3 w0.508: 209.24,15.57 J35.5 ; J35.5 207.56,17.24 ; J35.5 210.91,17.24 ; J35.5 209.24,18.92 ; 220.7,17.24 J35.6 ; J35.6 222.38,18.92 ; J35.6 222.38,15.57 ; J35.6 224.05,17.24
  L08_SIG2 w0.508: J35.6 222.38,18.92 ; J35.6 222.38,15.57 ; J35.6 224.05,17.24 ; J35.6 220.7,17.24 ; J35.5 209.24,18.92 ; J35.5 209.24,15.57 ; J35.5 210.91,17.24 ; J35.5 207.56,17.24
  L09_GND4 w0.508: J35.5 209.24,18.92 ; J35.5 210.91,17.24 ; J35.5 209.24,15.57 ; J35.5 207.56,17.24 ; 220.7,17.24 J35.6 ; J35.6 222.38,18.92 ; J35.6 222.38,15.57 ; J35.6 224.05,17.24
  BOTTOM w0.508: J35.6 222.38,18.92 ; J35.6 224.05,17.24 ; J35.6 222.38,15.57 ; J35.6 220.7,17.24 ; J35.5 209.24,18.92 ; J35.5 209.24,15.57 ; J35.5 210.91,17.24 ; J35.5 207.56,17.24
GNDUSB1: length 6.5
  TOP w0.381: J38.8 v2(188.94,8.68) ; J38.7 v2(199.27,11.23) ; J38.9 v2(200.01,8.68) ; J38.6 v2(189.69,11.23)
V0: length 3.7
  BOTTOM w0.127: MOD1.1 41.53,225.39 C35.1
V1: length 3.3
  BOTTOM w0.127: MOD1.2 43.81,224.61 C36.1
V2: length 3.1
  BOTTOM w0.127: MOD1.3 45.93,227.04 C37.1
V3: length 3.4
  BOTTOM w0.127: C38.1 48.13,224.7 MOD1.4
V4: length 3.6
  BOTTOM w0.127: C39.1 50.16,225.24 MOD1.5
V5_0HDMICONN: length 6.6
  TOP w0.254: J36.18 83,18.35 83.17,18.51 v2(84.85,18.51) U108.13
  BOTTOM w0.381: v2(84.85,18.51) 84.85,19.89 C707.1
VCC0V85: length 128.7
  TOP w0.152: U50.1 191.83,91.3
  TOP w0.381: v2(201.32,87.39) 190.42,87.39 189.69,88.13 189.69,89.63 190.26,90.2 v2(190.87,90.2) C213.1 191.83,90.26 191.83,91.3
  L08_SIG2 w0.381: v2(217.8,124.73) 215.39,124.73 213.36,126.76 203.83,126.76 202.36,128.23 199.8,128.23 199.56,128 199.55,128 199.51,127.95 198.68,127.95 197.76,128.87 197.76,128.94 197.74,128.96 197.74,130.06 196.34,131.46 194.82,131.46 194.06,132.22 192.79,132.22 191.26,133.75 191.26,140.78 189.6,142.45 v2(189.03,142.45) 189.03,143.35 187.91,144.46 v2(186.18,144.46)
  BOTTOM w0.381: v2(190.87,90.2) 189.45,91.62 189.45,93.71 189.09,94.07 188.94,94.07 188.57,94.44 188.57,96.64 188.32,96.89 187.91,96.89 187.25,97.55 C267.1 185.09,97.55 184.89,97.35 184.89,96.47 184.56,96.14 FB30.1 ; v2(186.18,144.46) 186.53,144.81 FB22.1 ; v2(217.8,124.73) 217.8,124.16 217.81,124.15 217.81,120.91 215.7,118.8 215.7,113.83 212.02,110.16 208.49,110.16 206.93,108.61 206.93,102.94 206.48,102.48 202.29,102.48 201.19,101.38 201.19,88.38 201.27,88.3 201.27,87.44 v2(201.32,87.39) ; C205.1 189.19,142.28 v2(189.03,142.45)
VCC1V2: length 1.1
  BOTTOM w0.381: C699.1 v2(104.6,53.58)
VCC1V2_XDS: length 13.2
  TOP w0.381: L2.2 v2(276.83,101.21) ; C29.2 274.18,98.78 v2(274.17,98.8) ; C24.1 v2(275.69,102.48) ; R83.2 v2(274.18,100.59) ; C25.2 v2(275.69,104.51)
  TOP w0.508: TP196.1 275.88,106.47 ; TP196.1 273.88,106.47 ; TP196.1 274.88,107.47 ; TP196.1 274.88,105.46
  BOTTOM w0.508: 274.88,105.46 TP196.1 ; TP196.1 275.88,106.47 ; TP196.1 274.88,107.47 ; TP196.1 273.88,106.47
  vias: v2(274.42,104.51) v2(274.42,102.48) v2(274.42,101.46) v2(275.31,101.46)
VCC1V2_XDS_CVDD: length 41.1
  TOP w0.254: U17.H11 v1(242.22,53.25) ; U17.K12 v1(243.02,51.65) ; U17.G7 v1(238.22,54.05) ; U17.H6 v1(237.42,53.25) ; U17.J12 v1(243.02,52.45) ; U17.G13 v1(243.82,54.05) ; U17.J6 v1(237.42,52.45) ; U17.N7 v1(238.22,48.45) ; U17.M12 v1(243.02,49.25) ; U17.M9 v1(239.82,49.25) ; U17.H10 v1(241.42,53.25) ; U17.G8 v1(239.02,54.05) ; U17.E15 v1(245.42,55.65) ; U17.L14 v1(244.62,50.05) ; U17.E5 v1(236.62,55.65) ; U17.H7 v1(238.22,53.25) ; U17.L12 v1(243.02,50.05) ; U17.N8 v1(239.02,48.45) ; U17.H13 v1(243.82,53.25) ; U17.H14 v1(244.62,53.25) ; U17.M8 v1(239.02,49.25) ; U17.K6 v1(237.42,51.65) ; U17.H12 v1(243.02,53.25)
  TOP w0.381: v2(234.82,37.23) 234.89,37.16 C388.1 ; v2(239.75,41.72) C57.2 C59.2 ; v2(253.85,34.89) 253.57,34.89 253.5,34.82 R296.1
  L08_SIG2 w0.102: v1(237.42,53.25) 237.03,53.63 237.03,55.23 v1(236.62,55.65) 236.11,55.13 236.11,53.06 236.32,52.85 237.02,52.85 v1(237.42,52.45) ; 244.4,49.32 244.4,48.83 243.43,48.83 v1(243.02,49.25) 243.44,49.67 244.05,49.67 244.4,49.32
  BOTTOM w0.381: C61.2 240.25,48.82 v1(239.82,49.25) ; v2(237.49,36.97) 237.3,37.16 C388.1 ; C401.2 236.73,41.29 v2(237.49,42.05) ; C57.2 v2(239.75,41.72) 239,41.72 238.23,40.95 C59.2 ; v1(243.02,51.65) v1(243.02,52.45) v1(243.02,53.25) ; C406.2 237.42,51.02 v1(237.42,51.65) ; C420.1 242.95,35.97 v2(242.95,34.56) ; C423.2 236.45,55.82 v1(236.62,55.65)
  vias: v2(269.75,95.52) v2(269.88,96.79) v2(270.76,95.52) v2(270.89,96.79) v2(271.78,95.52) v2(271.91,96.79)
VCC1V2_XDS_PLL: length 30.7
  TOP w0.381: v2(241.27,38.29) C90.2 C399.2 ; R296.2 253.35,33.12 v2(253.85,33.62) ; FL13.1 245.41,32.6 v2(245.87,32.15) ; v2(246.38,31) 246.38,31.43 247.78,32.83 FL16.1
  L03_SIG1 w0.381: v2(245.87,32.15) 244.86,33.16 241.43,33.16 240.41,34.18 240.41,35.98 241.27,36.84 v2(241.27,38.29)
  L08_SIG2 w0.381: v2(253.85,33.62) 253.28,33.62 253.2,33.7 246.51,33.7 245.87,33.06 v2(245.87,32.15)
  BOTTOM w0.381: v2(241.27,38.29) C90.2 C399.2
VCC1V8_AUD: length 5.4
  TOP w0.254: U96.36 279.61,42.39 v2(279.91,42.69)
  TOP w0.381: R536.2 280.12,47.39 v2(280.11,47.37) ; C326.1 v2(279.91,43.96) ; R543.2 v2(280.16,45.73)
  BOTTOM w0.381: C679.1 v2(279.91,43.96)
VCC1V8_EMMC: length 93.9
  TOP w0.203: U29.P3 178.01,189.28 v2(178.17,189.44) ; v1(177.44,187.34) 177.42,187.32 177.42,187.29 177.51,187.38 U29.M4 U29.N4 ; U29.C6 U29.C7 176.01,183.63 v1(175.76,183.88) ; v1(177.03,189.95) 177.03,189.94 177.01,189.93 U29.P5
  TOP w0.381: v2(176.78,197.19) C133.1 176.83,198.24 177.66,198.24 178.02,197.89 U34.6 179.07,197.89 179.6,197.36 179.6,194.62 179.1,194.12 R287.2 178.43,191.72 178.81,191.34 178.81,190.07 v2(178.17,189.44) 180.53,189.44 182.01,190.91 R856.2 ; v2(176.9,169.37) R281.2 R269.2 ; R286.2 183.27,174.82 183.54,174.55 183.54,173.34 183.13,172.93 180.97,172.93 v2(180.08,173.82) 180.08,174.44 179.7,174.82 R299.2 ; R258.2 173.47,196.2 173.91,196.64 v2(174.19,196.64) 175.12,195.71 R268.2 ; R292.2 v2(178.81,169.37) ; C113.1 v2(170.85,176.32) ; v2(176.78,173.69) 176.33,174.14 176.21,174.14 175.63,174.72 R271.2 ; R260.2 v2(174.11,173.69)
  L03_SIG1 w0.381: v2(174.11,173.69) 174.88,174.46 176,174.46 v2(176.78,173.69) ; v2(176.78,197.19) 176.44,197.19 175.64,196.38 174.4,196.38 174.19,196.59 v2(174.19,196.64) ; v1(175.76,183.88) 176.46,183.17 177.09,183.17 178.28,184.37 178.28,186.86 177.8,187.34 v1(177.44,187.34) 177.44,187.87 178.17,188.6 v2(178.17,189.44) 177.53,189.44 v1(177.03,189.95) ; v2(176.78,173.69) 176.78,170.07 176.9,169.94 v2(176.9,169.37) v2(178.81,169.37) 180.46,169.37 v2(181.71,170.63) ; v2(176.78,173.69) 177.59,173.69 178.33,174.44 179.45,174.44 179.55,174.34 179.56,174.34 v2(180.08,173.82)
  BOTTOM w0.381: C145.1 178.44,189.17 v2(178.17,189.44) ; v1(175.76,183.88) 170.85,178.96 v2(170.85,176.32) 170.85,172.89 171.19,172.55 173.54,172.55 174.11,173.12 v2(174.11,173.69) ; R304.2 v2(181.71,170.63)
VCC1V8_WLAN: length 93.5
  TOP w0.381: v2(181.28,217.79) 181.46,217.98 U125.16 ; R69.1 v2(198.9,233.55) ; R138.2 191.41,219.54 190.65,220.3 v2(190.65,221.4) 192.25,221.4 192.37,221.28 C762.1 193.04,219.89 193.05,219.88 U128.16 ; R139.2 197.53,220.44 197.14,220.06 v2(197.13,220.06) ; v2(167.18,220.61) 167.75,220.61 167.78,220.59 168.48,220.59 168.76,220.31 U126.16 ; R57.1 v2(190.5,234.62) ; J2.8 v2(192.91,239.03) 192.91,238.32 193.67,237.56 C15.1 ; R55.1 v2(187.45,234.62) ; R54.1 v2(185.93,234.62) ; R56.1 v2(188.98,234.62) ; R58.1 v2(192.02,234.62) ; v2(184.4,234.62) R53.1 R52.1 ; FB8.2 168.34,226.75
  TOP w0.508: v2(198.9,233.55) 198.88,233.57 193.67,233.57 192.62,234.62 v2(192.02,234.62)
  L03_SIG1 w0.381: v2(176.12,223.28) 179.6,223.28 181.28,221.6 v2(181.28,217.79) 184.89,221.4 v2(190.65,221.4) 191.49,221.4 192.84,220.06 v2(197.13,220.06) 197.13,228.08 198.04,229 198.04,232.7 v2(198.9,233.55)
  BOTTOM w0.381: C68.2 v2(167.18,220.61) 167.18,224.27 v2(168.34,225.43) ; v2(168.34,225.43) 170.49,223.28 v2(176.12,223.28) 176.39,223.55 C65.2 ; v2(168.34,225.43) 168.34,226.75 FB8.2 ; C368.1 v2(192.91,239.03)
  vias: v2(168.4,224.55) v2(169.16,226.2) v2(169.16,225.44)
VCC1V8_XDS: length 40.3
  TOP w0.254: U6.12 C17.2
  TOP w0.381: TP197.1 285.75,89.78 v2(284.2,89.78) 283.45,89.78 283.2,89.52 C16.1 283.2,89.27 283.45,89.02 v2(284.2,89.02) ; C28.2 254.65,94.78 254.15,94.78 v2(253.75,95.19) U12.15 ; C17.2 v2(281.17,92.71) ; D2.3 v2(285.92,104.2)
  TOP w0.508: 286.11,88.42 TP197.1 ; TP197.1 285.1,89.42 ; TP197.1 286.11,90.43 ; TP197.1 287.11,89.42
  L06_PWR2 w0.508: 285.1,89.42 TP197.1 ; TP197.1 286.11,90.43 ; TP197.1 286.11,88.42
  L08_SIG2 w0.381: v2(285.92,104.2) 284.11,104.2 283.21,103.29 283.21,100.57 284.58,99.2 284.58,97.5 281.17,94.08 v2(281.17,92.71)
  BOTTOM w0.381: R600.1 287.6,104.2 v2(285.92,104.2) ; v2(279.1,90.41) 279.12,90.39 279.73,90.39 280.01,90.67 R608.2 280.2,91.41 281.03,92.24 281.03,92.57 v2(281.17,92.71)
VCC1V8_XDS_DVDD18: length 45.1
  TOP w0.254: U17.K5 v1(236.62,51.65) ; U17.F14 v1(244.62,54.85) ; U17.P13 v1(243.82,47.65) ; U17.L6 v1(237.42,50.05) ; U17.R13 v1(243.82,46.85) ; U17.G10 v1(241.42,54.05) ; U17.G6 v1(237.42,54.05) ; U17.J13 v1(243.82,52.45) ; U17.G12 v1(243.02,54.05) ; U17.G11 v1(242.22,54.05)
  TOP w0.381: C85.2 v2(244.45,41.85) ; FL5.1 254.43,42.48 254.76,42.81 v2(254.76,42.94)
  L08_SIG2 w0.102: v1(243.82,52.45) 243.41,52.86 243.41,53.66 v1(243.02,54.05) U17.G12 242.62,52.19 242.77,52.03 243.41,52.03 v1(243.82,52.45) ; v1(243.82,52.45) 244.22,52.05 244.22,51.25 243.87,50.89 243.03,50.89 242.6,50.47 242.6,48.22 242.8,48.02 242.86,48.02 242.86,48.03 243.44,48.03 v1(243.82,47.65) ; 240.96,53.58 240.88,53.66 237.81,53.66 v1(237.42,54.05) 237.84,54.47 241,54.47 v1(241.42,54.05)
  L08_SIG2 w0.381: v1(242.22,54.05) v1(241.42,54.05) 240.82,53.44 240.82,51.32 240.54,51.04 236.82,51.04 236.62,51.24 v1(236.62,51.65)
  BOTTOM w0.381: C55.2 240.68,54.05 v1(241.42,54.05) ; v1(236.62,51.65) 235.84,50.87 C44.2 ; FB6.2 232.58,52.93 v2(232.79,52.72) ; C389.2 242.92,45.28 243.5,45.86 243.5,45.96 243.82,46.28 v1(243.82,46.85) ; v2(244.45,41.85) C85.2 C395.2
  vias: v2(279.02,87.77) v2(279.02,86.76) v2(279.02,85.74) v2(280.29,87.77) v2(280.29,86.76) v2(280.29,85.74)
VCC3V0_BMC_BKL: length 4.1
  BOTTOM w0.381: R100.2 37.97,227.84 37.63,227.5 MOD1.A
VCC3V0_BMC_LCD: length 91.3
  TOP w0.381: U10.5 v2(125.74,228.04)
  L03_SIG1 w0.381: v2(125.74,228.04) 122.37,228.04 120.22,230.19 90.42,230.19 90.41,230.2 89.93,230.2 89.92,230.19 69.37,230.19 63.99,235.57 v2(42.31,235.57)
  BOTTOM w0.381: C387.2 125.39,229.74 125.74,229.39 v2(125.74,228.04) ; R112.1 v2(42.31,235.57)
VCC3V3_AUD: length 55.8
  TOP w0.254: v2(274.34,34.43) 274.84,34.93 U96.17 ; v2(280.96,37.39) 280.39,36.82 279.76,36.82 279.69,36.89 U96.25 ; U96.24 278.34,35.62 v2(278.76,35.19) ; U96.44 v2(274.84,43.99) ; U96.16 v2(274.34,35.29)
  TOP w0.381: R894.2 286.35,42.38 v2(286.35,41.35) U97.5 ; v2(290.38,43.92) U75.4 292.47,46.26 292.79,46.58 R503.1 ; C316.1 276.61,45.61 v2(276.22,45.23) ; C339.1 281.93,36.98 281.56,37.35 280.99,37.35 v2(280.96,37.39) ; C294.2 v2(277.66,50.52) ; R534.1 v2(272.43,48.04)
  L03_SIG1 w0.381: v2(290.38,43.92) 288.53,43.92 287.68,43.07 287.65,43.07 287.27,42.69 287.12,42.69 286.35,41.92 v2(286.35,41.35) ; v2(274.34,35.29) v2(274.34,34.43) ; v2(272.43,48.04) 272.43,47.12 273.76,45.79 274.02,45.79 274.7,45.1 274.7,44.13 v2(274.84,43.99) ; v2(277.66,50.52) 276.22,49.08 v2(276.22,45.23)
  BOTTOM w0.381: v2(277.66,50.52) 277.09,50.52 277.08,50.51 276.63,50.51 275.49,49.37 275.49,48.83 274.83,48.17 R755.1 ; v2(286.35,41.35) 286.35,39.69 C692.2 ; v2(278.76,35.19) 278.36,35.6 278.36,36.2 C695.1 ; v2(274.84,43.99) 274.84,44.56 275.09,44.81 275.09,44.82 275.43,45.16 275.44,45.16 275.51,45.23 v2(276.22,45.23) 276.61,45.61 C674.1 276.62,46.62 278.18,46.62 278.61,46.19 278.61,41.42 278.76,41.26
VCC3V3_BMC: length 415.2
  TOP w0.127: U20.J9 U20.J10 ; U20.J9 U20.J8 ; U20.J9 73.89,197.27 v1(73.89,197.5) 74.16,197.23 U20.H9 ; U20.J9 U20.H9 ; U20.P17 78.38,194.28 v1(78.38,194.66) 78.31,194.73 U20.N16 ; U20.L12 U20.M12 ; U20.L12 U20.L11 ; U20.L12 v1(76.45,195.73) ; U20.L12 U20.K12 U20.K11 U20.L10 U20.M11 ; U20.M12 76.29,195.23 v1(76.61,194.91) ; U20.M12 U20.M11 ; U20.H9 74.43,197.66 v1(74.5,197.73) U20.G10 ; U20.M11 75.43,194.75 v1(75.41,194.73) 75.41,194.71 U20.P10 ; v1(72.37,198.3) 72.3,198.23 U20.F4 ; v1(71.95,198.74) 71.88,198.67 71.87,198.67 71.75,198.54 71.74,198.54 U20.F3 ; U20.J8 73.5,196.73 73.48,196.71 v1(73.43,196.71) U20.K7 U20.K8 U20.J8
  TOP w0.203: C819.1 46,210.67 45.86,210.53 44.86,210.53 44.65,210.32 U130.6 ; C818.1 44.48,211.35 44.25,211.13 44.25,209.92 ; v2(41.88,115.15) 42.13,114.91 43.78,114.91 43.92,115.05 U76.7 ; U67.42 v2(172.81,86.63) ; U24.1 v2(86.38,182.14) ; U35.1 v2(86.63,170.21) ; U67.31 v2(168.41,86.63)
  TOP w0.254: U129.7 33.75,208.52 35.47,208.52 35.75,208.24 C816.1 v2(36.46,209.12) ; U33.1 v2(58.69,172.11)
  TOP w0.381: v2(81.87,192.55) 81.9,192.52 R663.1 ; R847.2 v2(40.79,210.4) ; R310.2 57.77,170.56 58.17,170.96 v2(58.8,170.96) ; C134.1 58.43,171.85 v2(58.69,172.11) ; R291.2 v2(41.53,176.67) ; R861.2 v2(58.8,180.23) ; R282.2 v2(41.53,178.2) ; 43.96,179.85 44.15,180.04 v2(44.15,180.81) ; 43.96,179.85 C122.1 ; 43.96,179.85 44.73,179.85 45.01,179.57 45.01,179.24 45.43,178.82 U31.1 47.51,178.96 R266.2 ; R254.2 v2(102.42,235.98) ; R199.2 90.07,196.15 v2(90.14,196.23) ; v2(81.66,107.58) 85.85,103.39 123.95,103.39 125.08,104.53 v2(127.55,104.53) C756.2 ; R204.2 v2(90.17,193.18) ; R190.2 v2(93.55,232.5) ; R197.2 v2(93.55,234.03) ; C31.1 v2(122.16,230.89) ; C31.1 122.16,229.08 122.07,228.99 U10.1 ; C31.1 121.38,229.76 121.27,229.65 R109.2 ; R175.2 v2(93.55,229.45) ; R135.1 v2(28.7,219.34) ; U16.8 v2(78.95,207.49) ; v2(86.38,182.14) 86.11,181.88 C109.1 85.23,181.21 85.08,181.05 R255.2 ; U14.8 v2(68.54,207.61) ; C58.2 27.18,222.42 v2(27.41,222.65) U13.15 ; C93.1 82.66,195.47 v2(81.95,195.47) ; C756.2 128.32,103.06 128.67,102.72 U122.1 ; C756.2 R832.1 ; C92.1 v2(68.07,197.12) ; R132.1 v2(24.13,221.25) ; R225.2 v2(65.67,187.48) ; R168.2 128.44,236.73 128.49,236.67 v2(129.1,236.67) ; C143.1 86.06,170.07 86.19,170.21 v2(86.63,170.21) ; R134.1 v2(25.46,219.34) ; v2(35.35,203.15) C681.1 37.27,203.15 37.3,203.12 U101.5 ; R180.2 83.45,198.91 v2(84.2,199.66) ; R264.2 v2(73.52,158.64) ; v2(94.49,199.02) R179.2 96,198.35 96.12,198.22 R188.2 ; R193.2 v2(90.14,194.71) ; R183.2 v2(93.55,230.98) ; R498.2 178.32,89.92 v2(178.94,89.3) ; R202.2 90.04,191.68 v2(90.07,191.66) ; R290.2 68.31,173.08 68.78,172.61 v2(68.96,172.61) ; R878.2 v2(97.16,203.85) ; R316.2 v2(88.91,164.97) ; v2(73.3,203.09) 72.36,204.03 C69.1 ; C819.1 v2(47,212.04) ; R224.2 v2(109.92,235.66) ; v2(81.92,173.5) R862.2 R860.2 ; R196.2 v2(118.81,235.54) ; v2(92.52,235.35) R289.2 ; U30.1 v2(70.73,176.28) 68.57,176.28 68.31,176.02 R280.2 ; R103.2 v2(28.07,234.58) ; C818.1 v2(43.46,212.04) ; R837.2 v2(34.95,212.18) ; R227.2 v2(82.63,188.88) 83.49,188.88 U21.4 ; R219.2 v2(61.32,161.71) ; R633.2 260.21,223.8 v2(260.22,223.79) ; R313.2 v2(84.26,236.02) ; R150.2 v2(262.65,208.71)
  L03_SIG1 w0.381: v2(148.69,93.13) 148.69,93.21 149.04,93.55 149.04,94.79 147.5,96.33 145.97,96.33 140.46,101.84 130.23,101.84 v2(127.55,104.53)
  L06_PWR2 w0.508: 128.31,234.58 TP195.1 ; TP195.1 129.31,235.59 ; TP195.1 129.31,233.58 ; TP195.1 130.31,234.58 ; 102.31,189.75 J11.1 ; J11.1 103.38,190.82 ; J11.1 104.44,189.75 ; J11.1 103.38,188.69
  L08_SIG2 w0.381: 256.29,222.01 232.16,222.01 225.3,215.15 213.49,215.15 211.2,212.87 208.03,212.87 207.01,213.88 202.95,213.88 202.31,214.52 182.75,214.52 179.58,217.69 179.58,221.99 176.28,225.29 v2(176.28,232.93) ; 256.29,222.01 256.29,216.98 v2(258.43,214.83) ; 256.29,222.01 257.05,222.77 259.21,222.77 v2(260.22,223.79) ; v2(148.69,93.13) 146.99,93.13 146.1,92.24 146.1,89.17 146.83,88.44 158.52,88.44 159.05,88.97 163.86,88.97 166.85,85.97 167.75,85.97 v2(168.41,86.63)
  BOTTOM w0.178: U66.7 180.19,92.83
  BOTTOM w0.254: 182.48,89.95 C279.2 182.38,90.95 181.89,91.44 181.89,91.54 180.92,92.51 180.5,92.51 180.19,92.83 ; v1(73.43,196.71) 74,196.14 C102.1
  BOTTOM w0.305: C70.1 75.27,196.29 75.51,196.05 76.12,196.05 v1(76.45,195.73)
  BOTTOM w0.381: C461.1 72.24,176.28 v2(70.73,176.28) ; v2(90.07,191.66) R664.2 R662.2 R660.2 ; R501.2 168.67,86.37 v2(168.41,86.63) 168.41,87.64 C654.2 ; v2(81.95,195.47) 82.66,195.47 C93.1 ; R646.1 R645.1 v2(83.19,204.47) ; 182.48,89.95 v2(182.75,89.68) ; C92.1 v2(68.07,197.12) ; v2(258.43,214.83) 258.43,210.98 260.7,208.71 v2(262.65,208.71) ; v2(82.63,188.88) 82.63,188.31 82.68,188.26 82.68,188.23 83.06,187.85 ; R747.2 C663.1 44.07,108.5 v2(43.48,107.91) ; C653.2 172.81,87.75 v2(172.81,86.63) 172.81,85.51 C287.2 ; C400.1 78.88,209.02 79.25,208.65 79.25,208.35 78.95,208.06 v2(78.95,207.49) ; R591.1 v2(27.29,246.51) ; R659.2 R660.2 ; R660.2 v2(90.14,194.71) ; C403.1 68.34,208.82 68.54,208.63 v2(68.54,207.61) ; R607.1 v2(129.27,230.89) ; v2(91.31,189.63) 91.12,189.82 88.52,189.82 88.14,189.44 R859.2 ; R661.1 82.45,191.4 81.87,191.98 v2(81.87,192.55) ; R601.2 v2(27.04,239.17) ; R106.1 v2(36.07,234.41) ; C410.2 73.54,203.33 v2(73.3,203.09) ; v2(55.75,180.74) 56.13,180.35 56.13,179.87 55.88,179.62 R863.1 ; 83.06,187.85 82.93,187.85 82.55,187.47 82.55,186.83 v2(81.92,186.2) ; 83.06,187.85 C435.1 ; R741.2 v2(178.94,89.3) ; C436.2 v2(74.68,189.75)
  vias: v2(146.94,216.55) v2(146.92,214.54) v2(146.94,213.37) v2(147.05,212.34) v2(147.7,216.55) v2(147.83,213.88) v2(148.34,213.12) v2(149.38,213.12) v2(149.48,214.26)
VCC3V3_CDCM: length 152.8
  TOP w0.203: v2(142.75,84.85) 142.75,85.23 142.75,85.23 142.75,85.95 ; 139.7,85.49 140.08,85.49 140.25,85.66 U62.13 ; 139.53,89.17 137.85,89.17 v2(137.82,89.14) ; U62.34 v2(147.35,91.17) ; U62.48 v2(140.25,93.77)
  TOP w0.254: U62.10 138.51,87.67 v2(138.51,87.67)
  TOP w0.305: v2(100.48,98.82) 100.53,98.77 FL8.1
  TOP w0.381: U31.16 52.96,179.42 53.24,179.69 53.24,180.39 C467.2 v2(54.25,180.53) ; FL7.1 v2(117.98,92.98) 117.86,93.11 115.19,93.11 114.6,92.52 FL9.1 ; 139.7,85.49 139.19,85.49 v2(138.68,84.98) ; R485.1 v2(134.14,91.33) ; R475.1 138.87,98.68 139.12,98.44 139.12,97.87 v2(139.05,97.81)
  L08_SIG2 w0.381: v2(100.48,98.82) 100.08,99.23 100.08,116.96 85.17,131.87 85.17,134.3 72.01,147.46 58.09,147.46 55.98,149.57 55.98,178.3 54.25,180.02 v2(54.25,180.53)
  BOTTOM w0.381: v2(137.82,89.14) 137.08,88.41 C282.1 ; R731.1 v2(135.37,95.75) ; R895.2 148.8,100.13 148.08,100.85 v2(147.57,100.85) C612.1 146.32,99.95 146.98,99.29 C276.1 146.98,97.89 147.21,97.67 C641.1 ; C639.1 139.32,98.07 v2(139.05,97.81) ; v2(135.38,93.87) 136.27,93.87 136.51,93.63 R733.1 ; C646.1 138.7,84.96 v2(138.68,84.98) ; C643.1 146.43,90.05 147.35,90.97 v2(147.35,91.17) ; v2(138.51,87.67) 138.95,87.67 C642.1 ; v2(142.75,84.85) 144.78,84.85 145.18,85.25 C647.1
VCC3V3_CP2105: length 188.7
  TOP w0.203: 23.5,93.36 23.29,93.15 U146.6
  TOP w0.254: 16.25,58.82 17.46,58.82 17.96,59.32 U74.6 ; 16.25,58.82 16.78,59.35 16.78,59.85 17.16,60.22 U74.5 ; 16.25,58.82 C290.1 16.14,59.69 v2(16.13,59.7) ; U129.6 34.87,208.07 35.46,207.48 35.6,207.48 36.36,206.72 C817.1 v2(36.46,205.85)
  TOP w0.381: v2(25.39,95.12) C821.1 24.64,93.61 24.38,93.36 23.5,93.36
  L03_SIG1 w0.508: v2(36.46,205.85) 36.46,206.42 35.65,207.23 32.84,207.23 31.5,205.88 31.5,192.9 36.07,188.33 36.07,135.78 34.34,134.05 23.93,134.05 23.42,133.54 23.42,100.42 24.51,99.33 24.51,96 v2(25.39,95.12) 24.49,94.22 18.82,94.22 17.91,93.31 17.91,61.1 16.51,59.7 v2(16.13,59.7)
VCC3V3_DC_CONN: length 56.5
  TOP w0.381: FL19.1 201.69,232.21 201.52,232.04 v2(201.59,232.04) ; FL19.1 201.69,234.2 201.83,234.34 201.68,234.34 201.68,234.34 v2(201.76,234.34) ; FL19.1 v2(200.56,233.36) ; v2(30.68,149.34) U119.2 ; FB5.1 203.57,227.25 203.83,226.99 v2(203.83,226.91) ; FB5.1 201.58,227.25 v2(201.29,226.96) ; FB5.1 202.56,226.38 v2(202.54,226.35) ; R852.1 v2(232.33,238.98) ; v2(26.75,185.41) 26.8,185.36 U118.2 v2(34.16,185.36) ; v2(244.22,241.44) 243.07,240.29 R824.1 241.53,240.29 241.3,240.51 C104.1 240.54,239.21 240.33,239 U116.16 241.05,238.05 241.33,238.32 241.33,238.37
  TOP w0.508: 227.33,236.25 TP194.1 ; TP194.1 226.33,237.25 ; TP194.1 227.33,238.25 ; TP194.1 228.33,237.25
  L05_PWR1 w0.508: 226.33,237.25 TP194.1 ; TP194.1 228.33,237.25 ; TP194.1 227.33,236.25 ; TP194.1 227.33,238.25
  L08_SIG2 w0.381: v2(34.16,185.36) 34.16,183.66 32.13,181.62 32.13,175.02 v2(31.75,174.64)
  BOTTOM w0.381: C752.1 34.46,185.65 v2(34.16,185.36) ; C744.1 228.55,235.66 228.74,235.86 228.74,235.96 229.32,236.54 C746.1 ; C754.1 30.26,149.76 v2(30.68,149.34)
  BOTTOM w0.508: 226.33,237.25 TP194.1 ; TP194.1 227.33,238.25 ; TP194.1 228.33,237.25 ; TP194.1 227.33,236.25
  vias: v2(31.12,150.51) v2(31.75,151.14) v2(32.38,186.37) v2(32.38,150.51) v2(32.94,186.93) v2(33.02,151.14) v2(33.3,187.72) v2(33.48,186.2) v2(33.66,150.51) v2(199.64,235.47) v2(199.64,234.58) v2(199.77,233.44) v2(200.46,234.28) v2(200.53,235.47) v2(226.06,235.09) v2(226.06,233.57) v2(226.01,226.91) v2(226.19,231.79) v2(226.19,230.77) v2(226.19,229.76) v2(226.95,235.09) v2(226.95,233.57) v2(227.08,231.79) v2(227.08,230.77) v2(227.08,229.76) v2(228.09,231.79) v2(228.09,230.77) v2(228.09,229.76) v2(228.38,224.21) v2(228.35,223.03) v2(228.35,222.14) v2(228.98,231.79) v2(228.98,230.77) v2(228.98,229.76) v2(229.23,223.03) v2(229.23,222.14) v2(230.25,223.03) v2(230.25,222.14) v2(231.14,223.03) v2(231.14,222.14) v2(244.22,243.22) v2(244.22,242.33) v2(245.24,243.22) v2(245.24,242.33) v2(245.24,241.44) v2(245.24,240.55) v2(246.25,243.22) v2(246.25,242.33) v2(246.25,241.44) v2(246.25,240.55) v2(247.27,243.22) v2(247.27,242.33) v2(247.27,241.44) v2(247.27,240.55)
VCC3V3_DCIN: length 1313.9
  TOP w0.152: v2(245.82,168.63) U32.N5
  TOP w0.203: v2(253.31,140.98) 253.31,140.5 253.02,140.21 ; U147.7 31.26,92.7 ; 86.15,183.64 U24.24 ; U24.23 87.67,185.53 87.3,185.89 v2(86.36,185.89) ; U67.7 172.81,92.35 172.9,92.27 172.9,91.43 172.03,90.57 v2(172.03,90.16) ; v2(255.91,148.3) 255.91,149.37 255.02,150.25 254.13,150.25 ; v2(192.39,97.29) 193.24,98.14 194.49,98.14 194.72,97.91 194.72,96.87 195.06,96.52 U56.1 ; U33.24 58.7,173.61 v2(58.69,173.62) ; v2(59.82,175.43) 59.98,175.26 U33.23 ; U42.8 273.3,150.51 273.05,150.76 273.05,151.27 273.3,151.53 274.34,151.53 U42.10 275.32,151.51 275.46,151.65 275.46,152.92 275.21,153.18 v2(274.57,153.18) ; U43.2 v2(251.9,150.25) ; U124.6 42.97,106.62 v2(42.82,106.47) 43.08,106.22 U124.7 ; U67.18 168.41,91.98 168.44,91.96 168.44,91.47 168.31,91.34 168.31,90.8 168.41,90.7 168.41,90.52 168.38,90.48 v2(168.38,90.24) ; 31.62,93.23 31.75,93.1 U147.6 ; U76.6 43.31,115.45 v2(43.31,115.46) ; 22.89,93.52 U146.7 ; U41.23 226.44,98.16 226.53,98.07 v2(228.23,98.07) ; U44.6 244.92,148.49 v2(245.19,148.22) ; U132.23 218.35,92.89 v2(218.39,92.93) ; 157.78,148.53 U112.5 ; v2(80.31,176.29) 80.3,176.28 U30.16 ; U42.6 v2(275.56,149.51) ; U32.D8 248.89,175.07 249.51,175.68 250.02,175.68 250.18,175.53 C126.2
  TOP w0.254: U48.6 v2(257.52,138.21) ; R912.1 195.83,144.29 v2(195.58,144.54) ; U95.8 292.78,38.26 292.59,38.07 v2(292.08,38.07) ; C129.2 118.1,195.45 117.73,195.09 C135.1 ; U43.2 254.13,150.25 ; 289.18,200.24 288.78,199.85 U141.16 ; U48.1 253.02,140.21 ; U132.24 216.64,90.68 216.63,90.69 C781.2 ; U32.F3 U32.F2 U32.E1 ; R893.1 277.09,200.78 v2(276.76,201.11) ; U43.6 256.35,148.75 v2(255.91,148.3) ; U41.24 227.51,99.11 227.52,99.1 C162.2 ; U35.23 v2(87.92,173.5) ; C136.2 85.6,171.71 U35.24 ; U51.21 92.73,114 93.52,114.79 ; U46.6 v2(245.46,139.35)
  TOP w0.305: U98.1 C318.2 ; U64.16 v2(196.58,154.42)
  TOP w0.381: v2(208.89,146.19) C786.1 208.89,147.99 208.2,148.68 U135.1 ; v2(22.37,95.12) C308.1 23.11,93.74 22.89,93.52 ; U86.5 11.74,45.13 v2(11.94,45.32) ; U106.5 129.17,29.61 129.33,29.76 v2(129.87,29.76) ; U131.5 226.3,246.54 v2(226.31,246.52) ; v2(87.92,173.5) 86.24,173.5 85.47,172.73 85.47,171.61 C136.2 ; U68.5 v2(46.14,120.93) ; R239.2 v2(107.7,183.4) ; U93.16 v2(29.37,123.26) ; v2(29.61,95.41) C822.1 31.42,94.5 31.62,94.3 31.62,93.23 ; R849.2 v2(19.18,93.36) ; v2(209.77,170.3) 209.6,170.47 R321.1 ; v2(292.84,141.92) 292.87,141.96 FB52.1 ; U140.5 129.06,33.3 v2(129.03,33.26) ; R371.1 276.48,148.59 v2(275.56,149.51) ; 239.27,172.48 v2(239.9,173.12) 241.17,173.12 ; C125.2 238.52,175.01 ; v2(276.89,153.43) R359.2 v2(280.72,153.43) ; FB53.1 293.25,243.61 v2(293.24,243.6) ; R192.1 v2(62.41,195.54) ; v2(102.39,184.06) 102.74,184.42 U23.5 ; U100.1 C320.2 v2(34.53,192.27) ; v2(162.18,141.83) 161.54,142.47 161.54,143.14 161.92,143.52 162.18,143.52 R376.1 ; R491.1 195.12,148.4 195.49,148.77 v2(196.58,148.77) ; v2(208.03,177.43) 208.14,177.55 R339.2 208.17,178.45 209.55,178.45 209.97,178.87 U127.5 ; R478.1 205.02,95.52 205.26,95.76 v2(205.26,96.01) ; FB14.1 v2(229.49,83.83) ; U133.16 232.9,93.59 v2(233.27,93.97) 233.27,94.15 232.83,94.59 232.77,94.59 C782.2 ; FB7.1 178.35,217.99 v2(178.82,218.45) ; R564.1 296.67,45.48 v2(295.66,46.5) ; v2(203.66,152.49) 203.36,152.19 R870.1 202.54,151.37 202.31,151.14 202.31,148.17 v2(203.1,147.39) 203.1,148.25 204.15,149.31 U135.6 205.5,148.31 205.71,148.1 C785.2 ; R377.1 163.72,143.76 164.34,143.14 164.34,142.47 v2(163.7,141.83) ; v2(91.06,178.2) R276.2 R275.2 ; U14.1 v2(68.54,216.34) ; R236.2 v2(107.57,185.05) ; v2(188.8,140.45) 188.85,140.5 188.85,141.26 189.46,141.87 C784.2 ; v2(188.8,140.45) 189.73,139.52 U59.6 190.89,139.52 191.6,140.24 R869.1 ; v2(188.8,140.45) 187.99,140.45 187.63,140.09 U59.1 ; C792.1 42.61,106.68 v2(42.82,106.47) ; R348.1 v2(220.47,94.74) ; v2(192.15,189.5) 192.46,189.19 R344.1 ; R333.1 v2(209.36,186.15) ; 157.78,148.53 157.91,148.66 C710.2 158.79,149.53 159.51,150.26 159.51,152.01 v2(160.25,152.75) 160.25,146.22 160.42,146.05 R784.2 ; U64.16 v2(196.58,148.77) ; v2(196.58,148.77) U64.1 ; R11.2 v2(92.74,118.02) ; R886.2 v2(282.7,69.86) ; v2(203.2,67.45) 202.63,67.45 202.6,67.48 201.35,67.48 200.39,68.43 R518.1 ; C781.2 215.91,91.47 v2(216.08,91.64) ; C233.1 v2(148.03,104.15) ; U26.5 102.01,179.47 v2(101.57,179.03) ; v2(209.93,93.61) C532.1 210.84,92.36 211.05,92.15 U47.5 ; v2(101.71,195.96) R884.2 R883.2 ; R796.1 v2(229.23,145.94) ; R1.1 v2(89.69,117.95) ; R698.1 v2(209.09,168.94) ; R527.1 183.99,54.21 v2(184.02,54.24) ; v2(106.55,188.79) 106.3,189.04 R882.2 R881.2 ; R368.1 R369.1 v2(169.8,146.94) ; U38.8 197.54,168.98 197.12,168.56 C147.1 v2(196.16,167.74) ; U40.2 v2(202.13,179.85) ; C265.1 v2(192.39,97.29) ; R274.2 R273.2 ; v2(229.36,158.38) 229.23,158.26 R858.1 ; v2(29.61,91.98) C820.1 30.99,92.98 31.26,92.7 ; v2(295.17,30.67) 294.32,30.67 R557.1 R550.1 ; R3.1 v2(96.79,117.86) ; U139.5 C800.2 v2(297.05,66.31) ; FB32.1 v2(77.82,54.59) ; v2(250.81,176.29) C126.2 ; v2(108.83,192.98) 108.84,192.98 C798.1 108.82,193.94 U138.5 ; R378.1 v2(165.23,145.98) ; U5.5 226.56,244.32 v2(226.74,244.15) ; C318.2 39.33,156.77 39.75,156.35 41.86,156.35 v2(41.94,156.43) ; R251.2 v2(106.68,179.97) ; R845.1 v2(64.49,220.13) 70.84,220.13 71.42,219.55 v2(71.42,218.85) R844.1 ; R497.1 v2(91.21,117.86) ; R238.2 v2(98.03,182.65) ; v2(92.58,178.2) R277.2 R278.2 ; C162.2 v2(228.23,98.07) ; v2(59.82,175.43) 59.66,175.27 58.93,175.27 58.69,175.04 v2(58.69,173.62) 58.56,173.75 C131.2 ; U16.1 v2(78.95,216.21) ; R871.2 v2(31.37,88.91) ; v2(230.82,111.65) C783.2 230.77,110.76 229.77,110.76 229.35,111.18 U134.16 ; C322.2 v2(291.77,35.18) 292.78,35.18 U95.1 ; U95.8 291.69,39.78 v2(291.69,39.78) C323.1 ; v2(95.76,114.64) 94.93,115.47 C1.1 ; v2(119.58,12.44) 119.58,12.65 119.03,13.21 FB48.1 118.8,12.54 v2(118.87,12.46) ; R249.2 v2(97.39,180.85) ; FB49.1 v2(230.68,31.97) ; C284.1 v2(46.19,122.44) ; R301.1 v2(185.55,195.3) ; R66.1 219.14,245.06 v2(219.2,245.12) ; R223.2 v2(118.75,211.85) ; R894.1 v2(287.29,43.72) ; R248.2 v2(261.11,179.59) ; R379.1 v2(166.75,145.98) ; C236.1 v2(147.41,102.38) ; U32.E1 241.08,174.42 240.79,174.13 ; 86.15,183.64 85.37,183.64 C106.2 85.61,184.16 v2(86.61,184.16) ; C311.1 v2(182.8,55.89)
  TOP w0.508: J39.1 275.21,157.55 ; J39.1 276.28,156.48 ; J39.1 274.14,156.48 ; J39.1 275.21,155.41 ; TP199.1 275.45,199 ; TP199.1 274.45,198 ; TP199.1 274.45,200 ; TP199.1 273.44,199 ; C1.1 94.2,115.47 93.52,114.79
  L03_SIG1 w0.203: v2(205.64,145.18) 205.92,144.9 205.92,141.01 204.98,140.07 203.71,140.07 203.33,140.45 203.33,145.35 202.64,146.04 194.69,146.04 189.1,140.45 v2(188.8,140.45)
  L03_SIG1 w0.381: v2(166.75,145.98) 165.99,146.74 165.99,148.1 166.37,148.48 168.26,148.48 v2(169.8,146.94) ; v2(229.36,158.38) 227,158.38 224.84,156.22 224.84,150.33 v2(229.23,145.94) 218.03,145.94 215.8,143.7 212.91,146.6 209.29,146.6 v2(208.89,146.19) ; v2(271.65,147.72) 273.76,147.72 v2(275.56,149.51) ; v2(274.57,153.18) 274.27,153.48 271.3,153.48 270.72,152.91 v2(270.62,152.91) ; v2(229.49,83.83) 226.14,80.48 226.14,66.36 221.39,61.61 v2(219.58,61.61) ; v2(219.05,207.38) 220.24,208.57 220.24,211.01 214.68,216.58 214.68,231.05 216.99,233.36 217.35,233.36 220.06,236.07 220.06,241.96 219.79,242.23 219.79,242.41 219.2,242.99 v2(219.2,245.12) ; v2(295.17,30.67) 295.22,30.67 295.96,31.41 295.96,34.05 294.83,35.18 v2(291.77,35.18) 291.77,35.75 292.08,36.06 v2(292.08,38.07) 292.08,38.82 291.69,39.21 v2(291.69,39.78) 291.69,43.47 290.19,44.97 288.54,44.97 v2(287.29,43.72) ; v2(228.23,98.07) 228.23,98.5 230.84,101.11 239.39,101.11 244.09,105.81 252.48,105.81 265.62,92.66 274.94,92.66 275.84,91.76 275.84,80.28 275.57,80.01 275.57,75.6 277.3,73.87 277.3,67.26 282.45,62.12 289.05,62.12 291.97,59.2 291.97,56.66 292.48,56.15 292.48,52.85 293.88,51.45 293.88,48.58 295.66,46.8 v2(295.66,46.5) ; 253.14,141.16 251.36,141.16 249.55,139.35 v2(245.46,139.35) 243.27,139.35 240.41,142.2 240.41,146.67 241.96,148.22 v2(245.19,148.22) 244.04,149.37 240.28,149.37 235.9,144.99 224.98,144.99 222.9,142.91 213.34,142.91 211.84,144.41 206.42,144.41 205.66,145.18 v2(205.64,145.18) ; 253.14,141.16 v2(253.31,140.98) ; 253.14,141.16 252.12,142.18 252.12,146.88 253.06,147.82 253.06,149.44 252.26,150.25 v2(251.9,150.25) ; v2(230.68,31.97) 230.66,31.99 230.66,37.33 229.49,38.5 227.2,38.5 226.69,39 226.69,39.89 227.23,40.43 227.23,56.28 223.75,59.76 209.91,59.76 203.2,66.46 v2(203.2,67.45) ; v2(218.17,50.42) 217.6,50.42 217.58,50.43 204.47,50.43 200.91,46.88 200.91,26.56 200.85,26.49 200.85,26.48 200.48,26.11 197.45,26.11 v2(196.57,25.24) 196.22,24.88 185.65,24.88 184.28,23.51 182.27,23.51 180.9,24.88 178.66,24.88 v2(178.44,25.11)
  L03_SIG1 w0.508: v2(293.24,243.6) 291.97,243.6 290.58,242.2 290.58,238.67 290.56,238.66 290.56,238.13 290.58,238.11 290.58,233.19 291.21,232.55 295.4,232.55 296.42,231.54 296.42,222.39 293.75,219.72 290.7,219.72 289.56,218.58 289.56,203.37 v2(290.3,202.63)
  L05_PWR1 w0.508: TP199.1 275.45,199 ; TP199.1 273.44,199 ; TP199.1 274.45,198 ; TP199.1 274.45,200
  L06_PWR2 w0.508: TP199.1 274.45,200 ; TP199.1 275.45,199 ; TP199.1 274.45,198 ; TP199.1 273.44,199 ; 275.21,155.41 J39.1 ; J39.1 276.28,156.48 ; J39.1 275.21,157.55
  L08_SIG2 w0.254: v2(203.2,67.45) 203.71,67.45 203.73,67.48 205.13,67.48 209.73,72.07 209.73,88.51 211,89.78 211,95.06 210.69,95.37 206.5,95.37 206.04,95.82 206.04,97.04 204.06,99.02 202.29,99.02 201.9,99.41 201.9,101.46 v2(203.58,103.14)
  L08_SIG2 w0.381: v2(160.25,152.75) 161.04,153.53 161.04,154.95 160.53,155.46 160.53,169.69 157.99,172.23 157.99,178.7 147.43,189.26 111.39,189.26 109.73,187.59 109.73,181.37 108.33,179.97 v2(106.68,179.97) 106.68,182.39 v2(107.7,183.4) ; v2(149.81,231.99) 149.78,231.99 145.41,236.36 v2(145.41,246.01) ; v2(297.05,66.31) 295.66,64.91 v2(295.66,46.5) 295.66,41.04 294.4,39.78 v2(291.69,39.78) ; v2(187.58,148.6) 186.82,148.6 185.27,147.06 185.27,144.44 186,143.7 187.4,143.7 188.34,142.76 188.34,141.49 188.8,141.04 v2(188.8,140.45) ; v2(219.2,245.12) 220.75,245.12 222,243.88 226.47,243.88 v2(226.74,244.15) 226.31,244.57 v2(226.31,246.52) ; v2(245.46,139.35) 246.72,139.35 249.78,136.29 255.6,136.29 v2(257.52,138.21) ; v2(59.82,175.43) 60.73,174.51 64.14,174.51 64.78,175.16 64.78,178.04 v2(65.34,178.59) ; v2(219.58,61.61) 219.58,57.42 218.17,56.01 v2(218.17,50.42)
  BOTTOM w0.178: U66.6 180.19,93.23
  BOTTOM w0.254: C280.1 181.61,92.6 180.98,93.23 180.19,93.23
  BOTTOM w0.381: v2(276.89,153.43) 276.89,152.77 277.11,152.54 277.99,152.54 C714.1 ; v2(282.7,69.86) 282.7,71.01 283.34,71.64 293.12,71.64 297.05,67.71 v2(297.05,66.31) ; C775.1 129.06,33.29 v2(129.03,33.26) ; v2(43.31,115.46) 43.45,115.6 C661.1 ; R665.2 90.28,188.62 v2(90.81,188.1) ; v2(145.41,246.01) 145.44,246.04 R750.1 ; v2(101.57,179.03) 101.79,178.82 C453.1 ; v2(275.56,149.51) 275.32,149.75 C518.1 274.46,150.52 274.28,150.7 C711.2 274.28,152.88 v2(274.57,153.18) ; R589.1 60.68,137.71 v2(60.46,137.49) 59.99,137.96 R588.1 ; v2(73.56,135.63) 73.69,135.75 R15.1 ; C396.2 68.58,216.3 v2(68.54,216.34) 68.92,216.34 v2(71.42,218.85) ; R895.1 151.34,99.46 v2(151.84,99.96) ; v2(245.82,168.63) 246.27,168.18 C493.2 246.64,166.9 C498.1 246.64,163.74 v2(246.62,163.72) ; v2(168.38,90.24) 168.53,90.08 168.53,89.64 C650.2 ; v2(257.52,138.21) 257.51,138.19 C545.1 ; C690.1 29.39,123.24 v2(29.37,123.26) ; R12.1 71.13,137.81 v2(71.19,137.87) ; C377.2 v2(226.74,244.15) ; v2(280.72,153.43) 280.72,153.43 280.72,152.86 280.42,152.56 C712.1 ; R910.1 v2(200.15,156.61) ; U136.1 196.58,152.61 v2(196.58,154.42) ; v2(196.58,154.42) 195.34,154.42 194.88,153.96 C789.2 ; v2(196.58,154.42) 196.07,154.93 R492.1 ; v2(87.92,173.5) 88.16,173.74 88.16,174.89 86.77,176.29 v2(80.31,176.29) C460.2 ; C713.2 257.64,150.34 256.94,149.64 C519.1 256.94,148.49 256.79,148.35 255.96,148.35 v2(255.91,148.3) ; U37.16 214.68,81.23 C486.2 213.7,81.26 213.21,81.75 213.21,83.02 212.01,84.22 210.03,84.22 208.91,85.33 208.91,91.79 209.93,92.8 v2(209.93,93.61) ; R835.2 44.64,102.87 v2(44.45,103.06) ; R253.2 v2(270.62,152.91) ; v2(129.87,29.76) 129.87,29.1 129.62,28.85 C703.2 ; C717.2 243.67,149.53 244.09,149.11 244.09,149.04 244.11,149.02 C520.1 245.06,148.35 v2(245.19,148.22) ; R874.1 203.35,147.63 v2(203.1,147.39) ; v2(163.7,147.84) 163.96,147.84 164.47,148.35 R706.1 ; v2(79.02,137.86) 79,137.85 R16.1 ; R735.2 196.87,24.2 196.55,24.52 196.55,25.21 v2(196.57,25.24) ; v2(151.48,98.19) 151.09,97.8 C632.1 ; C397.2 78.95,212.71 v2(78.95,216.21) ; C648.2 170.59,88.51 170.97,88.89 171.84,88.89 C649.2 172.3,89.9 v2(172.03,90.16) ; v2(117.09,196.99) 117.27,196.81 117.27,191.23 118.97,189.52 118.97,183.71 117.22,181.96 117.22,180.1 v2(117.04,179.92) ; C723.2 253.52,140.78 v2(253.31,140.98) ; v2(226.31,246.52) 226.24,246.6 C776.1 ; C280.1 182.48,93.37 v2(182.22,93.64) ; R675.2 v2(65.34,178.59) ; C791.1 C790.2 ; C790.2 208.33,153.97 v2(208.28,154.02) ; C790.2 208.33,152.41 208.2,152.28 U137.1 U137.6 204.66,151.21 203.66,152.21 v2(203.66,152.49) ; R726.1 v2(218.17,50.42) ; C761.2 209.69,178.11 209.17,177.59 208.18,177.59 v2(208.03,177.43) ; v2(102.39,184.06) 102.55,183.9 C441.1 104.05,183.9 104.14,183.99 107.11,183.99 v2(107.7,183.4) ; v2(67.38,137.74) 67.31,137.68 R13.1 ; C671.1 v2(11.94,45.32) ; v2(245.46,139.35) 245.44,139.33 C533.1 244.11,140.01 244.05,140.06 C720.2 ; C645.2 195.83,149.52 v2(196.58,148.77) 196.58,147.01 U136.16 ; v2(202.13,179.85) 202.3,179.68 C159.1 ; v2(111.76,112.41) 110.62,112.41 110.22,112.81 R526.1 ; C265.1 v2(192.39,97.29) ; R749.2 v2(9.65,45.48) ; R709.1 v2(271.65,147.72)
  BOTTOM w0.508: J39.1 275.21,157.55 ; J39.1 275.21,155.41 ; J39.1 276.28,156.48
  BOTTOM w0.635: R706.1 R705.1
  BOTTOM w0.762: v2(84.73,136.21) 83.62,136.21 81.98,137.85 R14.1
  vias: v2(86.49,178.2) v2(105.79,24.3) v2(106.3,23.89) v2(116.46,198.26) v2(116.46,179.52) v2(116.56,180.56) v2(116.59,196.61) v2(116.71,197.63) v2(117.07,179.21) v2(117.07,178.5) v2(117.6,198.39) v2(118.11,197.75) v2(118.75,86.37) v2(118.75,85.1) v2(120.02,86.37) v2(120.02,85.1) v2(120.02,83.83) v2(123.83,89.55) v2(125.09,89.55) v2(126.37,89.55) v2(127.64,89.55) v2(128.27,87.01) v2(128.27,85.74) v2(128.27,84.47) v2(128.27,83.2) v2(128.27,81.93) v2(128.91,89.55) v2(129.54,85.74) v2(129.54,84.47) v2(129.54,83.2) v2(129.54,81.93) v2(130.17,89.55) v2(147.83,99.33) v2(150.62,47.26) v2(151.48,96.66) v2(152.15,46.24) v2(153.29,47.26) v2(165.2,146.57) v2(165.91,146.01) v2(231.39,172.99) v2(231.39,171.97) v2(231.52,175.15) v2(231.52,174.39) v2(232.66,175.15) v2(232.66,174.26) v2(232.66,172.99) v2(232.66,171.97) v2(235.46,174.26) v2(235.46,172.99) v2(237.36,174.26) v2(237.36,171.97) v2(239.27,174.26) v2(271.78,199.02) v2(271.78,197.88) v2(271.91,201.31) v2(271.91,200.29) v2(272.8,201.31) v2(272.8,199.02) v2(272.8,197.88) v2(272.92,200.29) v2(273.94,201.34) v2(273.94,200.42) v2(275.06,201.36) v2(275.08,200.42) v2(275.97,201.31) v2(275.97,200.42) v2(275.97,199.66) v2(276.73,200.29) v2(276.71,199.07) v2(277.62,158) v2(278.51,158) v2(279.4,158) v2(280.29,158) v2(280.29,157.11) v2(280.29,156.22) v2(280.42,155.34) v2(290.25,201.82)
